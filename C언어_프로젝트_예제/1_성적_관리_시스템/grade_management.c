/*
 * 성적 관리 시스템
 *
 * 이 프로그램은 학생들의 성적을 관리하는 콘솔 기반 프로그램입니다.
 * 학생 정보를 입력하고, 성적을 계산하며, 전체 학생들의 성적을 조회하고 정렬합니다.
 *
 * 작성자: 코딩 쏙 학원
 * 날짜: 2023-11-01
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <ctype.h>

// 상수 정의
#define MAX_STUDENTS 100  // 최대 학생 수
#define MAX_NAME_LENGTH 50 // 최대 이름 길이
#define FILENAME "students.dat" // 데이터 파일 이름

// 학생 구조체 정의
typedef struct {
    int id;             // 학번
    char name[MAX_NAME_LENGTH]; // 이름
    int korean;         // 국어 점수
    int english;        // 영어 점수
    int math;           // 수학 점수
    int total;          // 총점
    float average;      // 평균
    char grade;         // 등급 (A, B, C, D, F)
} Student;

// 전역 변수
Student students[MAX_STUDENTS]; // 학생 배열
int studentCount = 0;            // 현재 학생 수

// 함수 선언
void displayMenu();
void addStudent();
void displayAllStudents();
void calculateGrade(Student *student);
void sortStudents();
void saveToFile();
void loadFromFile();
void searchStudent();
void updateStudent();
void deleteStudent();
void clearInputBuffer();
int getValidInt(const char* prompt, int min, int max);

// 메인 함수
int main() {
    int choice;

    // 프로그램 시작 시 파일에서 데이터 로드
    loadFromFile();

    printf("========================================
");
    printf("         성적 관리 시스템
");
    printf("========================================
");

    do {
        displayMenu();
        choice = getValidInt("메뉴를 선택하세요: ", 1, 9);

        switch (choice) {
            case 1:
                addStudent();
                break;
            case 2:
                displayAllStudents();
                break;
            case 3:
                sortStudents();
                break;
            case 4:
                searchStudent();
                break;
            case 5:
                updateStudent();
                break;
            case 6:
                deleteStudent();
                break;
            case 7:
                saveToFile();
                break;
            case 8:
                loadFromFile();
                break;
            case 9:
                printf("프로그램을 종료합니다.
");
                break;
            default:
                printf("잘못된 선택입니다. 다시 시도하세요.
");
        }

        if (choice != 9) {
            printf("
계속하려면 Enter 키를 누르세요...");
            clearInputBuffer();
            getchar(); // Enter 키 입력 대기
            printf("
");
        }
    } while (choice != 9);

    // 프로그램 종료 시 데이터 저장
    saveToFile();

    return 0;
}

// 메뉴 표시 함수
void displayMenu() {
    printf("========================================
");
    printf("                메뉴
");
    printf("========================================
");
    printf("1. 학생 정보 추가
");
    printf("2. 전체 학생 목록 조회
");
    printf("3. 성적순으로 정렬
");
    printf("4. 학생 정보 검색
");
    printf("5. 학생 정보 수정
");
    printf("6. 학생 정보 삭제
");
    printf("7. 데이터 저장
");
    printf("8. 데이터 불러오기
");
    printf("9. 종료
");
    printf("========================================
");
}

// 학생 정보 추가 함수
void addStudent() {
    if (studentCount >= MAX_STUDENTS) {
        printf("최대 학생 수에 도달했습니다. 더 이상 추가할 수 없습니다.
");
        return;
    }

    Student newStudent;

    printf("
=== 학생 정보 추가 ===
");

    // 학번 입력
    newStudent.id = getValidInt("학번을 입력하세요: ", 1, 999999);

    // 이름 입력
    printf("이름을 입력하세요: ");
    clearInputBuffer();
    fgets(newStudent.name, MAX_NAME_LENGTH, stdin);
    newStudent.name[strcspn(newStudent.name, "
")] = ''; // 개행 문자 제거

    // 국어 점수 입력
    newStudent.korean = getValidInt("국어 점수를 입력하세요 (0-100): ", 0, 100);

    // 영어 점수 입력
    newStudent.english = getValidInt("영어 점수를 입력하세요 (0-100): ", 0, 100);

    // 수학 점수 입력
    newStudent.math = getValidInt("수학 점수를 입력하세요 (0-100): ", 0, 100);

    // 총점 및 평균 계산
    newStudent.total = newStudent.korean + newStudent.english + newStudent.math;
    newStudent.average = (float)newStudent.total / 3.0f;

    // 등급 계산
    calculateGrade(&newStudent);

    // 학생 배열에 추가
    students[studentCount] = newStudent;
    studentCount++;

    printf("학생 정보가 추가되었습니다.
");
}

// 모든 학생 정보 표시 함수
void displayAllStudents() {
    if (studentCount == 0) {
        printf("저장된 학생 정보가 없습니다.
");
        return;
    }

    printf("
=== 전체 학생 목록 ===
");
    printf("========================================================================
");
    printf(" 학번	이름		국어	영어	수학	총점	평균	등급
");
    printf("========================================================================
");

    for (int i = 0; i < studentCount; i++) {
        printf(" %d	%s		%d	%d	%d	%d	%.2f	%c
",
               students[i].id, students[i].name,
               students[i].korean, students[i].english, students[i].math,
               students[i].total, students[i].average, students[i].grade);
    }

    printf("========================================================================
");
    printf("총 학생 수: %d
", studentCount);
}

// 등급 계산 함수
void calculateGrade(Student *student) {
    float avg = student->average;

    if (avg >= 90.0f) {
        student->grade = 'A';
    } else if (avg >= 80.0f) {
        student->grade = 'B';
    } else if (avg >= 70.0f) {
        student->grade = 'C';
    } else if (avg >= 60.0f) {
        student->grade = 'D';
    } else {
        student->grade = 'F';
    }
}

// 학생 성적순 정렬 함수 (내림차순)
void sortStudents() {
    if (studentCount == 0) {
        printf("저장된 학생 정보가 없습니다.
");
        return;
    }

    // 버블 정렬 알고리즘 사용
    for (int i = 0; i < studentCount - 1; i++) {
        for (int j = 0; j < studentCount - i - 1; j++) {
            if (students[j].total < students[j + 1].total) {
                // 학생 정보 교환
                Student temp = students[j];
                students[j] = students[j + 1];
                students[j + 1] = temp;
            }
        }
    }

    printf("학생들을 성적순(총점 내림차순)으로 정렬했습니다.
");
    displayAllStudents();
}

// 파일에 데이터 저장 함수
void saveToFile() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기

    if (file == NULL) {
        printf("파일을 열 수 없습니다.
");
        return;
    }

    // 학생 수 저장
    fwrite(&studentCount, sizeof(int), 1, file);

    // 학생 데이터 저장
    fwrite(students, sizeof(Student), studentCount, file);

    fclose(file);

    printf("%d명의 학생 정보가 파일에 저장되었습니다.
", studentCount);
}

// 파일에서 데이터 불러오기 함수
void loadFromFile() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기

    if (file == NULL) {
        printf("데이터 파일이 없거나 열 수 없습니다.
");
        return;
    }

    // 학생 수 불러오기
    fread(&studentCount, sizeof(int), 1, file);

    // 학생 데이터 불러오기
    fread(students, sizeof(Student), studentCount, file);

    fclose(file);

    printf("%d명의 학생 정보를 파일에서 불러왔습니다.
", studentCount);
}

// 학생 검색 함수
void searchStudent() {
    if (studentCount == 0) {
        printf("저장된 학생 정보가 없습니다.
");
        return;
    }

    int searchId;
    int found = 0;

    printf("
=== 학생 정보 검색 ===
");
    searchId = getValidInt("검색할 학번을 입력하세요: ", 1, 999999);

    printf("
검색 결과:
");
    printf("========================================================================
");
    printf(" 학번	이름		국어	영어	수학	총점	평균	등급
");
    printf("========================================================================
");

    for (int i = 0; i < studentCount; i++) {
        if (students[i].id == searchId) {
            printf(" %d	%s		%d	%d	%d	%d	%.2f	%c
",
                   students[i].id, students[i].name,
                   students[i].korean, students[i].english, students[i].math,
                   students[i].total, students[i].average, students[i].grade);
            found = 1;
            break;
        }
    }

    if (!found) {
        printf("학번 %d인 학생을 찾을 수 없습니다.
", searchId);
    }

    printf("========================================================================
");
}

// 학생 정보 수정 함수
void updateStudent() {
    if (studentCount == 0) {
        printf("저장된 학생 정보가 없습니다.
");
        return;
    }

    int updateId;
    int found = 0;

    printf("
=== 학생 정보 수정 ===
");
    updateId = getValidInt("수정할 학번을 입력하세요: ", 1, 999999);

    for (int i = 0; i < studentCount; i++) {
        if (students[i].id == updateId) {
            found = 1;

            printf("현재 정보:
");
            printf(" 학번: %d
", students[i].id);
            printf(" 이름: %s
", students[i].name);
            printf(" 국어: %d
", students[i].korean);
            printf(" 영어: %d
", students[i].english);
            printf(" 수학: %d
", students[i].math);

            printf("
새 정보를 입력하세요:
");

            // 이름 수정
            printf("새 이름 (현재: %s): ", students[i].name);
            clearInputBuffer();
            char newName[MAX_NAME_LENGTH];
            fgets(newName, MAX_NAME_LENGTH, stdin);
            newName[strcspn(newName, "
")] = '';

            if (strlen(newName) > 0) {
                strcpy(students[i].name, newName);
            }

            // 국어 점수 수정
            printf("새 국어 점수 (현재: %d): ", students[i].korean);
            int newKorean = getValidInt("", 0, 100);
            students[i].korean = newKorean;

            // 영어 점수 수정
            printf("새 영어 점수 (현재: %d): ", students[i].english);
            int newEnglish = getValidInt("", 0, 100);
            students[i].english = newEnglish;

            // 수학 점수 수정
            printf("새 수학 점수 (현재: %d): ", students[i].math);
            int newMath = getValidInt("", 0, 100);
            students[i].math = newMath;

            // 총점 및 평균 재계산
            students[i].total = students[i].korean + students[i].english + students[i].math;
            students[i].average = (float)students[i].total / 3.0f;

            // 등급 재계산
            calculateGrade(&students[i]);

            printf("학생 정보가 수정되었습니다.
");
            break;
        }
    }

    if (!found) {
        printf("학번 %d인 학생을 찾을 수 없습니다.
", updateId);
    }
}

// 학생 정보 삭제 함수
void deleteStudent() {
    if (studentCount == 0) {
        printf("저장된 학생 정보가 없습니다.
");
        return;
    }

    int deleteId;
    int found = 0;
    char confirm;

    printf("
=== 학생 정보 삭제 ===
");
    deleteId = getValidInt("삭제할 학번을 입력하세요: ", 1, 999999);

    for (int i = 0; i < studentCount; i++) {
        if (students[i].id == deleteId) {
            found = 1;

            printf("삭제할 학생 정보:
");
            printf(" 학번: %d
", students[i].id);
            printf(" 이름: %s
", students[i].name);
            printf(" 국어: %d
", students[i].korean);
            printf(" 영어: %d
", students[i].english);
            printf(" 수학: %d
", students[i].math);

            printf("
정말 삭제하시겠습니까? (y/n): ");
            clearInputBuffer();
            scanf("%c", &confirm);

            if (tolower(confirm) == 'y') {
                // 배열에서 해당 학생 정보 삭제 (뒤의 요소들을 앞으로 이동)
                for (int j = i; j < studentCount - 1; j++) {
                    students[j] = students[j + 1];
                }

                studentCount--;
                printf("학생 정보가 삭제되었습니다.
");
            } else {
                printf("삭제가 취소되었습니다.
");
            }

            break;
        }
    }

    if (!found) {
        printf("학번 %d인 학생을 찾을 수 없습니다.
", deleteId);
    }
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '\n' && c != EOF);
}

// 유효한 정수 입력 받기 함수
int getValidInt(const char* prompt, int min, int max) {
    int value;
    char input[100];
    
    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);
        
        // 입력된 문자열을 정수로 변환
        if (sscanf(input, "%d", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %d에서 %d 사이의 값을 입력하세요.\n", min, max);
            }
        } else {
            printf("오류: 유효한 정수를 입력하세요.\n");
        }
    }
}
    int c;
    while ((c = getchar()) != '
' && c != EOF);
}

// 유효한 정수 입력 받기 함수
int getValidInt(const char* prompt, int min, int max) {
    int value;
    char input[100];

    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);

        // 입력이 숫자인지 확인
        if (sscanf(input, "%d", &value) == 1) {
            // 범위 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("%d에서 %d 사이의 값을 입력하세요.
", min, max);
            }
        } else {
            printf("유효한 숫자를 입력하세요.
");
        }
    }
}
