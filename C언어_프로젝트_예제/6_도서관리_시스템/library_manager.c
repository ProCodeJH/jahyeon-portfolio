/*
 * 도서관리 시스템
 *
 * 이 프로그램은 도서관리 시스템으로서, 도서 정보를 추가, 조회, 수정, 삭제하고 검색하는 기능을 제공합니다.
 * 파일 입출력을 통해 데이터를 영구적으로 저장하고 불러올 수 있습니다.
 *
 * 작성자: 코딩 쏙 학원
 * 날짜: 2023-11-01
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <ctype.h>

// 상수 정의
#define MAX_BOOKS 100        // 최대 도서 수
#define MAX_TITLE_LENGTH 50   // 최대 제목 길이
#define MAX_AUTHOR_LENGTH 50  // 최대 저자 길이
#define MAX_PUBLISHER_LENGTH 50 // 최대 출판사 길이
#define FILENAME "books.dat"   // 데이터 파일 이름

// 도서 분류 정의
typedef enum {
    FICTION,      // 소설
    NONFICTION,   // 비소설
    SCIENCE,      // 과학
    HISTORY,       // 역사
    ART,          // 예술
    REFERENCE     // 참고서
    OTHER          // 기타
} BookCategory;

// 대출 상태 정의
typedef enum {
    AVAILABLE,     // 대출 가능
    BORROWED      // 대출 중
    OVERDUE       // 연체
} BookStatus;

// 대출 기록 구조체 정의
typedef struct {
    char borrowerName[50];  // 대출자 이름
    time_t borrowDate;       // 대출일
    time_t dueDate;          // 반납일
    int returned;            // 반납 여부
} BorrowRecord;

// 도서 구조체 정의
typedef struct {
    int id;                           // 도서 ID
    char title[MAX_TITLE_LENGTH];       // 제목
    char author[MAX_AUTHOR_LENGTH];     // 저자
    char publisher[MAX_PUBLISHER_LENGTH]; // 출판사
    int year;                          // 출판년도
    BookCategory category;               // 분류
    double price;                       // 가격
    BookStatus status;                  // 대출 상태
    BorrowRecord borrowRecord;             // 대출 기록
} Book;

// 전역 변수
Book books[MAX_BOOKS]; // 도서 배열
int bookCount = 0;       // 현재 도서 수

// 함수 선언
void displayMenu();
void addBook();
void displayAllBooks();
void searchBook();
void updateBook();
void deleteBook();
void saveToFile();
void loadFromFile();
void borrowBook();
void returnBook();
void displayBorrowHistory();
void clearInputBuffer();
int findBookIndex(int id);
int getValidInt(const char* prompt, int min, int max);
double getValidDouble(const char* prompt, double min, double max);
const char* getCategoryName(BookCategory category);
const char* getStatusName(BookStatus status);

// 메인 함수
int main() {
    int choice;

    // 프로그램 시작 시 파일에서 데이터 로드
    loadFromFile();

    printf("========================================
");
    printf("         도서관리 시스템
");
    printf("========================================
");

    do {
        displayMenu();
        printf("메뉴를 선택하세요: ");
        scanf("%d", &choice);
        clearInputBuffer();

        switch (choice) {
            case 1:
                addBook();
                break;
            case 2:
                displayAllBooks();
                break;
            case 3:
                searchBook();
                break;
            case 4:
                updateBook();
                break;
            case 5:
                deleteBook();
                break;
            case 6:
                borrowBook();
                break;
            case 7:
                returnBook();
                break;
            case 8:
                displayBorrowHistory();
                break;
            case 9:
                printf("프로그램을 종료합니다.
");
                break;
            default:
                printf("잘못된 선택입니다. 다시 시도하세요.
");
        }

        if (choice != 9) {
            printf("
계속하려면 Enter 키를 누르세요...");
            clearInputBuffer();
            getchar(); // Enter 키 입력 대기
            printf("
");
        }
    } while (choice != 9);

    // 프로그램 종료 시 데이터 저장
    saveToFile();

    return 0;
}

// 메뉴 표시 함수
void displayMenu() {
    printf("========================================
");
    printf("                메뉴
");
    printf("========================================
");
    printf("1. 도서 추가
");
    printf("2. 전체 도서 목록 조회
");
    printf("3. 도서 검색
");
    printf("4. 도서 정보 수정
");
    printf("5. 도서 정보 삭제
");
    printf("6. 도서 대출
");
    printf("7. 도서 반납
");
    printf("8. 대출 내역 조회
");
    printf("9. 종료
");
    printf("========================================
");
}

// 도서 추가 함수
void addBook() {
    if (bookCount >= MAX_BOOKS) {
        printf("최대 도서 수에 도달했습니다. 더 이상 추가할 수 없습니다.
");
        return;
    }

    Book newBook;

    printf("
=== 도서 추가 ===
");

    // 도서 ID 생성 (랜덤)
    int id;
    do {
        id = 1000 + rand() % 9000; // 1000-9999 사이의 랜덤 번호

        // 중복 확인
        if (findBookIndex(id) == -1) {
            break;
        }
    } while (1);

    newBook.id = id;

    // 제목 입력
    printf("제목: ");
    fgets(newBook.title, MAX_TITLE_LENGTH, stdin);
    newBook.title[strcspn(newBook.title, "
")] = ''; // 개행 문자 제거

    // 저자 입력
    printf("저자: ");
    fgets(newBook.author, MAX_AUTHOR_LENGTH, stdin);
    newBook.author[strcspn(newBook.author, "
")] = '';

    // 출판사 입력
    printf("출판사: ");
    fgets(newBook.publisher, MAX_PUBLISHER_LENGTH, stdin);
    newBook.publisher[strcspn(newBook.publisher, "
")] = '';

    // 출판년도 입력
    newBook.year = getValidInt("출판년도: ", 1900, 2023);

    // 분류 선택
    printf("분류 (1:소설, 2:비소설, 3:과학, 4:역사, 5:예술, 6:참고서, 7:기타): ");
    int category;
    scanf("%d", &category);
    clearInputBuffer();

    if (category < 1 || category > 7) {
        printf("잘못된 분류입니다. 기타로 설정합니다.
");
        newBook.category = OTHER;
    } else {
        newBook.category = (BookCategory)(category - 1);
    }

    // 가격 입력
    newBook.price = getValidDouble("가격: ", 0, 1000000);

    // 대출 상태 초기화
    newBook.status = AVAILABLE;
    strcpy(newBook.borrowRecord.borrowerName, "");
    newBook.borrowRecord.borrowDate = 0;
    newBook.borrowRecord.dueDate = 0;
    newBook.borrowRecord.returned = 1;

    // 도서 배열에 추가
    books[bookCount] = newBook;
    bookCount++;

    printf("
도서가 추가되었습니다.
");
    printf("도서 ID: %d
", newBook.id);
    printf("제목: %s
", newBook.title);
    printf("저자: %s
", newBook.author);
    printf("출판사: %s
", newBook.publisher);
    printf("출판년도: %d
", newBook.year);
    printf("분류: %s
", getCategoryName(newBook.category));
    printf("가격: %.2f원
", newBook.price);
}

// 전체 도서 조회 함수
void displayAllBooks() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    printf("
=== 전체 도서 목록 ===
");
    printf("=====================================================================================
");
    printf(" ID	제목			저자			분류		가격	상태
");
    printf("=====================================================================================
");

    for (int i = 0; i < bookCount; i++) {
        printf(" %d	%s		%s		%s		%.2f원	%s
", 
               books[i].id, books[i].title, books[i].author, 
               getCategoryName(books[i].category), books[i].price, 
               getStatusName(books[i].status));
    }

    printf("=====================================================================================
");
    printf("총 도서 수: %d
", bookCount);
}

// 도서 검색 함수
void searchBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    int choice;
    int foundCount = 0;

    printf("
=== 도서 검색 ===
");
    printf("1. 제목으로 검색
");
    printf("2. 저자로 검색
");
    printf("3. 분류로 검색
");
    printf("검색 방법을 선택하세요: ");
    scanf("%d", &choice);
    clearInputBuffer();

    char searchTerm[MAX_TITLE_LENGTH];

    switch (choice) {
        case 1:
            printf("검색할 제목을 입력하세요: ");
            fgets(searchTerm, MAX_TITLE_LENGTH, stdin);
            searchTerm[strcspn(searchTerm, "
")] = '';

            printf("
검색 결과:
");
            printf("=====================================================================================
");
            printf(" ID	제목			저자			분류		가격	상태
");
            printf("=====================================================================================
");

            for (int i = 0; i < bookCount; i++) {
                if (strstr(books[i].title, searchTerm) != NULL) {
                    printf(" %d	%s		%s		%s		%.2f원	%s
", 
                           books[i].id, books[i].title, books[i].author, 
                           getCategoryName(books[i].category), books[i].price, 
                           getStatusName(books[i].status));
                    foundCount++;
                }
            }
            break;

        case 2:
            printf("검색할 저자를 입력하세요: ");
            fgets(searchTerm, MAX_AUTHOR_LENGTH, stdin);
            searchTerm[strcspn(searchTerm, "
")] = '';

            printf("
검색 결과:
");
            printf("=====================================================================================
");
            printf(" ID	제목			저자			분류		가격	상태
");
            printf("=====================================================================================
");

            for (int i = 0; i < bookCount; i++) {
                if (strstr(books[i].author, searchTerm) != NULL) {
                    printf(" %d	%s		%s		%s		%.2f원	%s
", 
                           books[i].id, books[i].title, books[i].author, 
                           getCategoryName(books[i].category), books[i].price, 
                           getStatusName(books[i].status));
                    foundCount++;
                }
            }
            break;

        case 3:
            printf("검색할 분류를 선택하세요 (1:소설, 2:비소설, 3:과학, 4:역사, 5:예술, 6:참고서, 7:기타): ");
            int category;
            scanf("%d", &category);
            clearInputBuffer();

            if (category < 1 || category > 7) {
                printf("잘못된 분류입니다.
");
                return;
            }

            BookCategory searchCategory = (BookCategory)(category - 1);

            printf("
검색 결과:
");
            printf("=====================================================================================
");
            printf(" ID	제목			저자			분류		가격	상태
");
            printf("=====================================================================================
");

            for (int i = 0; i < bookCount; i++) {
                if (books[i].category == searchCategory) {
                    printf(" %d	%s		%s		%s		%.2f원	%s
", 
                           books[i].id, books[i].title, books[i].author, 
                           getCategoryName(books[i].category), books[i].price, 
                           getStatusName(books[i].status));
                    foundCount++;
                }
            }
            break;

        default:
            printf("잘못된 선택입니다.
");
            return;
    }

    printf("=====================================================================================
");

    if (foundCount == 0) {
        printf("검색 결과가 없습니다.
");
    } else {
        printf("총 %d개의 도서를 찾았습니다.
", foundCount);
    }
}

// 도서 정보 수정 함수
void updateBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    int id;
    int index;

    printf("
=== 도서 정보 수정 ===
");
    id = getValidInt("수정할 도서 ID를 입력하세요: ", 1000, 9999);

    // 도서 인덱스 찾기
    index = findBookIndex(id);

    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.
", id);
        return;
    }

    // 현재 정보 표시
    printf("
현재 도서 정보:
");
    printf("도서 ID: %d
", books[index].id);
    printf("제목: %s
", books[index].title);
    printf("저자: %s
", books[index].author);
    printf("출판사: %s
", books[index].publisher);
    printf("출판년도: %d
", books[index].year);
    printf("분류: %s
", getCategoryName(books[index].category));
    printf("가격: %.2f원
", books[index].price);
    printf("상태: %s
", getStatusName(books[index].status));

    // 새 정보 입력
    printf("새 제목 (현재: %s): ", books[index].title);
    char newTitle[MAX_TITLE_LENGTH];
    fgets(newTitle, MAX_TITLE_LENGTH, stdin);
    newTitle[strcspn(newTitle, "\n")] = '\0';
    
    if (strlen(newTitle) > 0) {
        strcpy(books[index].title, newTitle);
    }
    
    printf("새 저자 (현재: %s): ", books[index].author);
    char newAuthor[MAX_AUTHOR_LENGTH];
    fgets(newAuthor, MAX_AUTHOR_LENGTH, stdin);
    newAuthor[strcspn(newAuthor, "\n")] = '\0';
    
    if (strlen(newAuthor) > 0) {
        strcpy(books[index].author, newAuthor);
    }
    
    printf("새 출판사 (현재: %s): ", books[index].publisher);
    char newPublisher[MAX_PUBLISHER_LENGTH];
    fgets(newPublisher, MAX_PUBLISHER_LENGTH, stdin);
    newPublisher[strcspn(newPublisher, "\n")] = '\0';
    
    if (strlen(newPublisher) > 0) {
        strcpy(books[index].publisher, newPublisher);
    }
    
    printf("새 출판년도 (현재: %d): ", books[index].year);
    int newYear = getValidInt("새 출판년도: ", 1900, 2023);
    books[index].year = newYear;
    
    printf("새 분류 (현재: %s): ", getCategoryName(books[index].category));
    int category;
    scanf("%d", &category);
    clearInputBuffer();
    
    if (category < 1 || category > 7) {
        printf("잘못된 분류입니다. 기존 분류를 유지합니다.
");
    } else {
        books[index].category = (BookCategory)(category - 1);
    }
    
    printf("새 가격 (현재: %.2f원): ", books[index].price);
    double newPrice = getValidDouble("새 가격: ", 0, 1000000);
    books[index].price = newPrice;
    
    printf("도서 정보가 수정되었습니다.\n");
}

// 도서 삭제 함수
void deleteBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.\n");
        return;
    }
    
    int id;
    int index;
    char confirm;
    
    printf("\n=== 도서 삭제 ===\n");
    id = getValidInt("삭제할 도서 ID를 입력하세요: ", 1000, 9999);
    
    // 도서 인덱스 찾기
    index = findBookIndex(id);
    
    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.\n", id);
        return;
    }
    
    // 삭제할 도서 정보 표시
    printf("\n삭제할 도서 정보:\n");
    printf("도서 ID: %d\n", books[index].id);
    printf("제목: %s\n", books[index].title);
    printf("저자: %s\n", books[index].author);
    printf("출판사: %s\n", books[index].publisher);
    printf("출판년도: %d\n", books[index].year);
    printf("분류: %s\n", getCategoryName(books[index].category));
    printf("가격: %.2f원\n", books[index].price);
    printf("상태: %s\n", getStatusName(books[index].status));
    
    // 대출 중인 도서인지 확인
    if (books[index].status == BORROWED) {
        printf("대출 중인 도서는 삭제할 수 없습니다.\n");
        return;
    }
    
    printf("정말 삭제하시겠습니까? (y/n): ");
    scanf(" %c", &confirm);
    clearInputBuffer();
    
    if (tolower(confirm) != 'y') {
        printf("삭제가 취소되었습니다.\n");
        return;
    }
    
    // 배열에서 도서 삭제 (뒤의 요소들을 앞으로 이동)
    for (int i = index; i < bookCount - 1; i++) {
        books[i] = books[i + 1];
    }
    
    bookCount--;
    
    printf("도서가 삭제되었습니다.\n");
}

// 파일에 데이터 저장 함수
void saveToFile() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기
    
    if (file == NULL) {
        printf("파일을 열 수 없습니다.\n");
        return;
    }
    
    // 도서 수 저장
    fwrite(&bookCount, sizeof(int), 1, file);
    
    // 도서 데이터 저장
    fwrite(books, sizeof(Book), bookCount, file);
    
    fclose(file);
    
    printf("%d개의 도서 정보가 파일에 저장되었습니다.\n", bookCount);
}

// 파일에서 데이터 불러오기 함수
void loadFromFile() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기
    
    if (file == NULL) {
        printf("데이터 파일이 없거나 열 수 없습니다.\n");
        return;
    }
    
    // 도서 수 불러오기
    fread(&bookCount, sizeof(int), 1, file);
    
    // 도서 데이터 불러오기
    fread(books, sizeof(Book), bookCount, file);
    
    fclose(file);
    
    printf("%d개의 도서 정보를 파일에서 불러왔습니다.\n", bookCount);
}

// 도서 대출 함수
void borrowBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.\n");
        return;
    }
    
    int id;
    int index;
    char borrowerName[50];
    
    printf("\n=== 도서 대출 ===\n");
    id = getValidInt("대출할 도서 ID를 입력하세요: ", 1000, 9999);
    
    // 도서 인덱스 찾기
    index = findBookIndex(id);
    
    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.\n", id);
        return;
    }
    
    // 대출 가능 여부 확인
    if (books[index].status != AVAILABLE) {
        printf("이 도서는 이미 대출 중입니다.\n");
        printf("대출자: %s\n", books[index].borrowRecord.borrowerName);
        printf("대출일: ", books[index].borrowRecord.borrowerName);
        
        // 날짜 형식 변환
        struct tm *dateInfo = localtime(&books[index].borrowRecord.borrowDate);
        char dateStr[20];
        strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", dateInfo);
        printf("%s\n", dateStr);
        printf("반납일: ", books[index].borrowRecord.borrowerName);
        
        // 날짜 형식 변환
        dateInfo = localtime(&books[index].borrowRecord.dueDate);
        strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", dateInfo);
        printf("%s\n", dateStr);
        return;
    }
    
    // 대출자 이름 입력
    printf("대출자 이름: ");
    fgets(borrowerName, 50, stdin);
    borrowerName[strcspn(borrowerName, "\n")] = '\0';
    
    // 대출 정보 업데이트
    books[index].status = BORROWED;
    strcpy(books[index].borrowRecord.borrowerName, borrowerName);
    time(&books[index].borrowRecord.borrowDate);
    
    // 반납일 설정 (대출일 + 14일)
    time_t dueDate = books[index].borrowRecord.borrowDate + (14 * 24 * 60 * 60);
    books[index].borrowRecord.dueDate = dueDate;
    books[index].borrowRecord.returned = 0;
    
    printf("\n도서가 대출되었습니다.\n");
    printf("대출자: %s\n", books[index].borrowRecord.borrowerName);
    printf("반납일: ", books[index].borrowRecord.borrowerName);
    
    // 날짜 형식 변환
    struct tm *dateInfo = localtime(&dueDate);
    char dateStr[20];
    strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", dateInfo);
    printf("%s\n", dateStr);
}

// 도서 반납 함수
void returnBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.\n");
        return;
    }
    
    int id;
    int index;
    
    printf("\n=== 도서 반납 ===\n");
    id = getValidInt("반납할 도서 ID를 입력하세요: ", 1000, 9999);
    
    // 도서 인덱스 찾기
    index = findBookIndex(id);
    
    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.\n", id);
        return;
    }
    
    // 대출 중인지 확인
    if (books[index].status != BORROWED) {
        printf("이 도서는 대출 중이 아닙니다.\n");
        return;
    }
    
    // 반납 정보 업데이트
    books[index].status = AVAILABLE;
    books[index].borrowRecord.returned = 1;
    
    printf("\n도서가 반납되었습니다.\n");
    printf("대출자: %s\n", books[index].borrowRecord.borrowerName);
    printf("대출일: ", books[index].borrowRecord.borrowerName);
    
    // 날짜 형식 변환
    struct tm *dateInfo = localtime(&books[index].borrowRecord.borrowDate);
    char dateStr[20];
    strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", dateInfo);
    printf("%s\n", dateStr);
}

// 대출 내역 조회 함수
void displayBorrowHistory() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.\n");
        return;
    }
    
    int foundCount = 0;
    
    printf("\n=== 대출 내역 ===\n");
    printf("=====================================================================================\n");
    printf(" ID\t제목\t\t대출자\t\t대출일\t\t반납일\t\t상태\n");
    printf("=====================================================================================\n");
    
    // 대출 중인 도서 표시
    for (int i = 0; i < bookCount; i++) {
        if (books[i].status == BORROWED) {
            printf(" %d\t%s\t\t%s\t", 
                   books[i].id, books[i].title, books[i].borrowRecord.borrowerName);
            
            // 대출일 형식 변환
            struct tm *dateInfo = localtime(&books[i].borrowRecord.borrowDate);
            char dateStr[20];
            strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", dateInfo);
            printf("%s\t", dateStr);
            
            // 반납일 형식 변환
            if (books[i].borrowRecord.returned) {
                dateInfo = localtime(&books[i].borrowRecord.dueDate);
                strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", dateInfo);
                printf("%s\t", dateStr);
            } else {
                printf("-\t");
            }
            
            // 연체 여부 확인
            time_t currentTime;
            time(&currentTime);
            
            if (!books[i].borrowRecord.returned && 
                difftime(currentTime, books[i].borrowRecord.dueDate) > 0) {
                printf("연체\t");
            } else {
                printf("대출 중\t");
            }
            
            foundCount++;
        }
    }
    
    printf("=====================================================================================\n");
    
    if (foundCount == 0) {
        printf("대출 중인 도서가 없습니다.\n");
    } else {
        printf("총 %d개의 도서가 대출 중입니다.\n", foundCount);
    }
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '\n' && c != EOF);
}

// 도서 인덱스 찾기 함수
int findBookIndex(int id) {
    for (int i = 0; i < bookCount; i++) {
        if (books[i].id == id) {
            return i;
        }
    }
    return -1; // 찾지 못한 경우
}

// 유효한 정수 입력 받기 함수
int getValidInt(const char* prompt, int min, int max) {
    int value;
    char input[100];
    
    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);
        
        // 입력된 문자열을 정수로 변환
        if (sscanf(input, "%d", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %d에서 %d 사이의 값을 입력하세요.\n", min, max);
            }
        } else {
            printf("오류: 유효한 정수를 입력하세요.\n");
        }
    }
}

// 유효한 실수 입력 받기 함수
double getValidDouble(const char* prompt, double min, double max) {
    double value;
    char input[100];
    
    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);
        
        // 입력된 문자열을 실수로 변환
        if (sscanf(input, "%lf", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %.2f에서 %.2f 사이의 값을 입력하세요.\n", min, max);
            }
        } else {
            printf("오류: 유효한 숫자를 입력하세요.\n");
        }
    }
}

// 분류명 반환 함수
const char* getCategoryName(BookCategory category) {
    switch (category) {
        case FICTION:
            return "소설";
        case NONFICTION:
            return "비소설";
        case SCIENCE:
            return "과학";
        case HISTORY:
            return "역사";
        case ART:
            return "예술";
        case REFERENCE:
            return "참고서";
        case OTHER:
        default:
            return "기타";
    }
}

// 상태명 반환 함수
const char* getStatusName(BookStatus status) {
    switch (status) {
        case AVAILABLE:
            return "대출 가능";
        case BORROWED:
            return "대출 중";
        case OVERDUE:
            return "연체";
        default:
            return "알 수 없음";
    }
}    printf("
새 정보를 입력하세요 (변경하지 않으려면 Enter 키만 누르세요):
");

    // 제목 수정
    printf("새 제목 (현재: %s): ", books[index].title);
    char newTitle[MAX_TITLE_LENGTH];
    fgets(newTitle, MAX_TITLE_LENGTH, stdin);
    newTitle[strcspn(newTitle, "
")] = '';

    if (strlen(newTitle) > 0) {
        strcpy(books[index].title, newTitle);
    }

    // 저자 수정
    printf("새 저자 (현재: %s): ", books[index].author);
    char newAuthor[MAX_AUTHOR_LENGTH];
    fgets(newAuthor, MAX_AUTHOR_LENGTH, stdin);
    newAuthor[strcspn(newAuthor, "
")] = '';

    if (strlen(newAuthor) > 0) {
        strcpy(books[index].author, newAuthor);
    }

    // 출판사 수정
    printf("새 출판사 (현재: %s): ", books[index].publisher);
    char newPublisher[MAX_PUBLISHER_LENGTH];
    fgets(newPublisher, MAX_PUBLISHER_LENGTH, stdin);
    newPublisher[strcspn(newPublisher, "
")] = '';

    if (strlen(newPublisher) > 0) {
        strcpy(books[index].publisher, newPublisher);
    }

    // 출판년도 수정
    printf("새 출판년도 (현재: %d): ", books[index].year);
    int newYear = getValidInt("", 1900, 2023);

    if (newYear != 0) {
        books[index].year = newYear;
    }

    // 분류 수정
    printf("새 분류 (현재: %s) (1:소설, 2:비소설, 3:과학, 4:역사, 5:예술, 6:참고서, 7:기타): ", 
           getCategoryName(books[index].category));
    int newCategory;
    scanf("%d", &newCategory);
    clearInputBuffer();

    if (newCategory >= 1 && newCategory <= 7) {
        books[index].category = (BookCategory)(newCategory - 1);
    }

    // 가격 수정
    printf("새 가격 (현재: %.2f원): ", books[index].price);
    double newPrice = getValidDouble("", 0, 1000000);

    if (newPrice >= 0) {
        books[index].price = newPrice;
    }

    printf("도서 정보가 수정되었습니다.
");
}

// 도서 삭제 함수
void deleteBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    int id;
    int index;
    char confirm;

    printf("
=== 도서 삭제 ===
");
    id = getValidInt("삭제할 도서 ID를 입력하세요: ", 1000, 9999);

    // 도서 인덱스 찾기
    index = findBookIndex(id);

    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.
", id);
        return;
    }

    // 삭제할 도서 정보 표시
    printf("
삭제할 도서 정보:
");
    printf("도서 ID: %d
", books[index].id);
    printf("제목: %s
", books[index].title);
    printf("저자: %s
", books[index].author);
    printf("출판사: %s
", books[index].publisher);
    printf("출판년도: %d
", books[index].year);
    printf("분류: %s
", getCategoryName(books[index].category));
    printf("가격: %.2f원
", books[index].price);
    printf("상태: %s
", getStatusName(books[index].status));

    // 확인
    printf("
정말 삭제하시겠습니까? (y/n): ");
    scanf("%c", &confirm);
    clearInputBuffer();

    if (tolower(confirm) == 'y') {
        // 배열에서 해당 도서 삭제 (뒤의 요소들을 앞으로 이동)
        for (int i = index; i < bookCount - 1; i++) {
            books[i] = books[i + 1];
        }

        bookCount--;
        printf("도서가 삭제되었습니다.
");
    } else {
        printf("삭제가 취소되었습니다.
");
    }
}

// 도서 대출 함수
void borrowBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    int id;
    int index;
    char borrowerName[50];

    printf("
=== 도서 대출 ===
");
    id = getValidInt("대출할 도서 ID를 입력하세요: ", 1000, 9999);

    // 도서 인덱스 찾기
    index = findBookIndex(id);

    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.
", id);
        return;
    }

    // 대출 상태 확인
    if (books[index].status != AVAILABLE) {
        printf("이 도서는 현재 대출할 수 없습니다. 상태: %s
", 
               getStatusName(books[index].status));
        return;
    }

    // 대출자 이름 입력
    printf("대출자 이름: ");
    fgets(borrowerName, 50, stdin);
    borrowerName[strcspn(borrowerName, "
")] = '';

    // 대출 기록 업데이트
    strcpy(books[index].borrowRecord.borrowerName, borrowerName);
    time(&books[index].borrowRecord.borrowDate);

    // 반납일 설정 (14일 후)
    books[index].borrowRecord.dueDate = books[index].borrowRecord.borrowDate + (14 * 24 * 60 * 60);
    books[index].borrowRecord.returned = 0;

    // 대출 상태 변경
    books[index].status = BORROWED;

    printf("
도서가 대출되었습니다.
");
    printf("대출자: %s
", books[index].borrowRecord.borrowerName);
    printf("대출일: ", books[index].borrowRecord.borrowDate);

    // 날짜 형식 변환
    struct tm *borrowDateInfo = localtime(&books[index].borrowRecord.borrowDate);
    char borrowDateStr[20];
    strftime(borrowDateStr, sizeof(borrowDateStr), "%Y-%m-%d", borrowDateInfo);
    printf("%s
", borrowDateStr);

    // 반납일 형식 변환
    struct tm *dueDateInfo = localtime(&books[index].borrowRecord.dueDate);
    char dueDateStr[20];
    strftime(dueDateStr, sizeof(dueDateStr), "%Y-%m-%d", dueDateInfo);
    printf("반납일: %s
", dueDateStr);
}

// 도서 반납 함수
void returnBook() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    int id;
    int index;

    printf("
=== 도서 반납 ===
");
    id = getValidInt("반납할 도서 ID를 입력하세요: ", 1000, 9999);

    // 도서 인덱스 찾기
    index = findBookIndex(id);

    if (index == -1) {
        printf("도서 ID %d인 도서를 찾을 수 없습니다.
", id);
        return;
    }

    // 대출 상태 확인
    if (books[index].status != BORROWED) {
        printf("이 도서는 현재 대출 중이 아닙니다. 상태: %s
", 
               getStatusName(books[index].status));
        return;
    }

    // 반납 기록 업데이트
    books[index].borrowRecord.returned = 1;
    books[index].status = AVAILABLE;

    printf("
도서가 반납되었습니다.
");
    printf("도서 ID: %d
", books[index].id);
    printf("제목: %s
", books[index].title);
    printf("대출자: %s
", books[index].borrowRecord.borrowerName);
}

// 대출 내역 조회 함수
void displayBorrowHistory() {
    if (bookCount == 0) {
        printf("등록된 도서가 없습니다.
");
        return;
    }

    int count = 0;

    printf("
=== 대출 내역 ===
");
    printf("=====================================================================================
");
    printf(" ID	제목			대출자		대출일		반납일	상태
");
    printf("=====================================================================================
");

    for (int i = 0; i < bookCount; i++) {
        if (books[i].status == BORROWED || 
            (books[i].status == AVAILABLE && strlen(books[i].borrowRecord.borrowerName) > 0)) {
            printf(" %d	%s		%s		", 
                   books[i].id, books[i].title, books[i].borrowRecord.borrowerName);

            // 대출일 형식 변환
            struct tm *borrowDateInfo = localtime(&books[i].borrowRecord.borrowDate);
            char borrowDateStr[20];
            strftime(borrowDateStr, sizeof(borrowDateStr), "%Y-%m-%d", borrowDateInfo);
            printf("%s		", borrowDateStr);

            // 반납일 형식 변환
            if (books[i].borrowRecord.returned) {
                struct tm *dueDateInfo = localtime(&books[i].borrowRecord.dueDate);
                char dueDateStr[20];
                strftime(dueDateStr, sizeof(dueDateStr), "%Y-%m-%d", dueDateInfo);
                printf("%s	%s
", dueDateStr, getStatusName(books[i].status));
            } else {
                printf("미반납	%s
", getStatusName(books[i].status));
            }

            count++;
        }
    }

    printf("=====================================================================================
");

    if (count == 0) {
        printf("대출 내역이 없습니다.
");
    } else {
        printf("총 %d개의 대출 내역을 찾았습니다.
", count);
    }
}

// 파일에 데이터 저장 함수
void saveToFile() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기

    if (file == NULL) {
        printf("파일을 열 수 없습니다.
");
        return;
    }

    // 도서 수 저장
    fwrite(&bookCount, sizeof(int), 1, file);

    // 도서 데이터 저장
    fwrite(books, sizeof(Book), bookCount, file);

    fclose(file);

    printf("%d개의 도서 정보가 파일에 저장되었습니다.
", bookCount);
}

// 파일에서 데이터 불러오기 함수
void loadFromFile() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기

    if (file == NULL) {
        printf("데이터 파일이 없거나 열 수 없습니다.
");
        return;
    }

    // 도서 수 불러오기
    fread(&bookCount, sizeof(int), 1, file);

    // 도서 데이터 불러오기
    fread(books, sizeof(Book), bookCount, file);

    fclose(file);

    printf("%d개의 도서 정보를 파일에서 불러왔습니다.
", bookCount);
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '
' && c != EOF);
}

// 도서 인덱스 찾기 함수
int findBookIndex(int id) {
    for (int i = 0; i < bookCount; i++) {
        if (books[i].id == id) {
            return i;
        }
    }
    return -1; // 찾지 못한 경우
}

// 유효한 정수 입력 받기 함수
int getValidInt(const char* prompt, int min, int max) {
    int value;
    char input[100];

    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);

        // 입력된 문자열을 정수로 변환
        if (sscanf(input, "%d", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %d에서 %d 사이의 값을 입력하세요.
", min, max);
            }
        } else {
            printf("오류: 유효한 정수를 입력하세요.
");
        }
    }
}

// 유효한 실수 입력 받기 함수
double getValidDouble(const char* prompt, double min, double max) {
    double value;
    char input[100];

    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);

        // 입력된 문자열을 실수로 변환
        if (sscanf(input, "%lf", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %.2f에서 %.2f 사이의 값을 입력하세요.
", min, max);
            }
        } else {
            printf("오류: 유효한 숫자를 입력하세요.
");
        }
    }
}

// 분류 이름 반환 함수
const char* getCategoryName(BookCategory category) {
    switch (category) {
        case FICTION:
            return "소설";
        case NONFICTION:
            return "비소설";
        case SCIENCE:
            return "과학";
        case HISTORY:
            return "역사";
        case ART:
            return "예술";
        case REFERENCE:
            return "참고서";
        case OTHER:
            return "기타";
        default:
            return "알 수 없음";
    }
}

// 상태 이름 반환 함수
const char* getStatusName(BookStatus status) {
    switch (status) {
        case AVAILABLE:
            return "대출 가능";
        case BORROWED:
            return "대출 중";
        case OVERDUE:
            return "연체";
        default:
            return "알 수 없음";
    }
}
