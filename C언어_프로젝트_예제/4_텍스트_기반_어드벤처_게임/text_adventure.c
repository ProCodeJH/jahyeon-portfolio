/*
 * 텍스트 기반 어드벤처 게임
 *
 * 이 프로그램은 텍스트 기반의 간단한 어드벤처 게임입니다.
 * 플레이어는 다양한 방을 탐험하고, 아이템을 수집하며,
 * 퍼즐을 해결하고, 몬스터와 싸워 게임을 진행합니다.
 *
 * 작성자: 코딩 쏙 학원
 * 날짜: 2023-11-01
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <ctype.h>

// 상수 정의
#define MAX_NAME_LENGTH 50      // 최대 이름 길이
#define MAX_DESCRIPTION_LENGTH 200 // 최대 설명 길이
#define MAX_INVENTORY_SIZE 10   // 최대 인벤토리 크기
#define MAX_ROOMS 10          // 최대 방 수
#define MAX_ITEMS 10           // 최대 아이템 수
#define MAX_MONSTERS 5        // 최대 몬스터 수
#define FILENAME "savegame.dat" // 저장 파일 이름

// 아이템 구조체 정의
typedef struct {
    int id;                         // 아이템 ID
    char name[MAX_NAME_LENGTH];        // 아이템 이름
    char description[MAX_DESCRIPTION_LENGTH]; // 아이템 설명
    int damage;                     // 아이템 공격력
    int healing;                    // 아이템 회복량
} Item;

// 몬스터 구조체 정의
typedef struct {
    int id;                         // 몬스터 ID
    char name[MAX_NAME_LENGTH];        // 몬스터 이름
    char description[MAX_DESCRIPTION_LENGTH]; // 몬스터 설명
    int health;                     // 몬스터 체력
    int damage;                     // 몬스터 공격력
    int itemDrop;                   // 드랍 아이템 ID
} Monster;

// 방 구조체 정의
typedef struct {
    int id;                         // 방 ID
    char name[MAX_NAME_LENGTH];        // 방 이름
    char description[MAX_DESCRIPTION_LENGTH]; // 방 설명
    int exits[4];                  // 출구 (북, 동, 남, 서)
    int item;                       // 방에 있는 아이템 ID (-1이면 없음)
    int monster;                    // 방에 있는 몬스터 ID (-1이면 없음)
    int puzzle;                     // 방에 있는 퍼즐 ID (-1이면 없음)
    int puzzleSolved;                // 퍼즐 해결 여부
} Room;

// 플레이어 구조체 정의
typedef struct {
    char name[MAX_NAME_LENGTH];        // 플레이어 이름
    int health;                     // 플레이어 체력
    int maxHealth;                  // 플레이어 최대 체력
    int damage;                     // 플레이어 공격력
    int currentRoom;                 // 현재 방 ID
    Item inventory[MAX_INVENTORY_SIZE]; // 인벤토리
    int inventoryCount;              // 인벤토리 아이템 수
    int keys;                      // 가진 열쇠 수
} Player;

// 전역 변수
Room rooms[MAX_ROOMS];         // 방 배열
Item items[MAX_ITEMS];         // 아이템 배열
Monster monsters[MAX_MONSTERS]; // 몬스터 배열
Player player;               // 플레이어
int gameOver = 0;            // 게임 종료 여부
int gameWon = 0;             // 게임 승리 여부

// 함수 선언
void initGame();
void displayRoom();
void movePlayer(int direction);
void handleCombat(int monsterId);
void handlePuzzle(int puzzleId);
void handleItem(int itemId);
void saveGame();
void loadGame();
void displayInventory();
void checkWinCondition();
void clearInputBuffer();
int getValidInt(const char* prompt, int min, int max);

// 메인 함수
int main() {
    int choice;
    char input[20];

    // 난수 생성기 초기화
    srand(time(NULL));

    printf("========================================
");
    printf("        텍스트 어드벤처 게임
");
    printf("========================================
");

    // 새 게임 또는 불러오기 선택
    printf("1. 새 게임
");
    printf("2. 게임 불러오기
");
    printf("선택: ");
    scanf("%d", &choice);
    clearInputBuffer();

    if (choice == 1) {
        // 새 게임 초기화
        initGame();
    } else if (choice == 2) {
        // 게임 불러오기
        loadGame();
    } else {
        printf("잘못된 선택입니다. 새 게임을 시작합니다.
");
        initGame();
    }

    // 게임 루프
    while (!gameOver && !gameWon) {
        // 현재 방 정보 표시
        displayRoom();

        // 명령어 입력
        printf("
명령어 (이동: n/e/s/w, 인벤토리: i, 저장: s, 종료: q): ");
        fgets(input, sizeof(input), stdin);

        // 명령어 처리
        switch (tolower(input[0])) {
            case 'n': // 북쪽 이동
                movePlayer(0);
                break;
            case 'e': // 동쪽 이동
                movePlayer(1);
                break;
            case 's': // 남쪽 이동 또는 저장
                if (strlen(input) > 1 && tolower(input[1]) == 'a') {
                    saveGame();
                } else {
                    movePlayer(2);
                }
                break;
            case 'w': // 서쪽 이동
                movePlayer(3);
                break;
            case 'i': // 인벤토리 표시
                displayInventory();
                break;
            case 'q': // 종료
                printf("정말 종료하시겠습니까? (y/n): ");
                char confirm;
                scanf("%c", &confirm);
                clearInputBuffer();

                if (tolower(confirm) == 'y') {
                    gameOver = 1;
                    printf("게임을 종료합니다.
");
                }
                break;
            default:
                printf("알 수 없는 명령어입니다.
");
        }

        // 승리 조건 확인
        checkWinCondition();

        if (!gameOver && !gameWon) {
            printf("
계속하려면 Enter 키를 누르세요...");
            clearInputBuffer();
            getchar(); // Enter 키 입력 대기
        }
    }

    // 게임 결과 표시
    if (gameWon) {
        printf("
축하합니다! %s님은 게임에서 승리했습니다!
", player.name);
    } else if (gameOver) {
        printf("
게임 오버. %s님은 패배했습니다.
", player.name);
    }

    return 0;
}

// 게임 초기화 함수
void initGame() {
    // 플레이어 정보 초기화
    printf("
플레이어 이름을 입력하세요: ");
    fgets(player.name, MAX_NAME_LENGTH, stdin);
    player.name[strcspn(player.name, "
")] = ''; // 개행 문자 제거

    player.health = 100;
    player.maxHealth = 100;
    player.damage = 10;
    player.currentRoom = 0; // 시작 방
    player.inventoryCount = 0;
    player.keys = 0;

    // 방 초기화
    // 방 0: 시작 방
    rooms[0].id = 0;
    strcpy(rooms[0].name, "입구");
    strcpy(rooms[0].description, "당신은 어두운 동굴의 입구에 서 있습니다. 북쪽으로 이어지는 통로가 보입니다.");
    rooms[0].exits[0] = 1; // 북쪽 출구: 방 1
    rooms[0].exits[1] = -1; // 동쪽 출구: 없음
    rooms[0].exits[2] = -1; // 남쪽 출구: 없음
    rooms[0].exits[3] = -1; // 서쪽 출구: 없음
    rooms[0].item = 0; // 아이템 ID 0
    rooms[0].monster = -1; // 몬스터 없음
    rooms[0].puzzle = -1; // 퍼즐 없음
    rooms[0].puzzleSolved = 0; // 퍼즐 없음

    // 방 1: 복도
    rooms[1].id = 1;
    strcpy(rooms[1].name, "복도");
    strcpy(rooms[1].description, "긴 복도입니다. 양쪽으로 방이 있고, 남쪽으로 입구가 있습니다.");
    rooms[1].exits[0] = 2; // 북쪽 출구: 방 2
    rooms[1].exits[1] = 3; // 동쪽 출구: 방 3
    rooms[1].exits[2] = 0; // 남쪽 출구: 방 0
    rooms[1].exits[3] = -1; // 서쪽 출구: 없음
    rooms[1].item = -1; // 아이템 없음
    rooms[1].monster = 0; // 몬스터 ID 0
    rooms[1].puzzle = -1; // 퍼즐 없음
    rooms[1].puzzleSolved = 0; // 퍼즐 없음

    // 방 2: 보물 방
    rooms[2].id = 2;
    strcpy(rooms[2].name, "보물 방");
    strcpy(rooms[2].description, "반짝이는 보물이 가득한 방입니다. 하지만 문이 잠겨 있습니다.");
    rooms[2].exits[0] = -1; // 북쪽 출구: 없음
    rooms[2].exits[1] = -1; // 동쪽 출구: 없음
    rooms[2].exits[2] = 1; // 남쪽 출구: 방 1
    rooms[2].exits[3] = -1; // 서쪽 출구: 없음
    rooms[2].item = 1; // 아이템 ID 1
    rooms[2].monster = -1; // 몬스터 없음
    rooms[2].puzzle = 0; // 퍼즐 ID 0
    rooms[2].puzzleSolved = 0; // 퍼즐 미해결

    // 방 3: 퍼즐 방
    rooms[3].id = 3;
    strcpy(rooms[3].name, "퍼즐 방");
    strcpy(rooms[3].description, "벽에 이상한 기호들이 새겨져 있는 방입니다.");
    rooms[3].exits[0] = -1; // 북쪽 출구: 없음
    rooms[3].exits[1] = 4; // 동쪽 출구: 방 4
    rooms[3].exits[2] = -1; // 남쪽 출구: 없음
    rooms[3].exits[3] = 1; // 서쪽 출구: 방 1
    rooms[3].item = -1; // 아이템 없음
    rooms[3].monster = -1; // 몬스터 없음
    rooms[3].puzzle = 1; // 퍼즐 ID 1
    rooms[3].puzzleSolved = 0; // 퍼즐 미해결

    // 방 4: 보스 방
    rooms[4].id = 4;
    strcpy(rooms[4].name, "보스 방");
    strcpy(rooms[4].description, "거대한 몬스터가 당신을 기다리고 있습니다.");
    rooms[4].exits[0] = -1; // 북쪽 출구: 없음
    rooms[4].exits[1] = -1; // 동쪽 출구: 없음
    rooms[4].exits[2] = -1; // 남쪽 출구: 없음
    rooms[4].exits[3] = 3; // 서쪽 출구: 방 3
    rooms[4].item = -1; // 아이템 없음
    rooms[4].monster = 1; // 몬스터 ID 1 (보스)
    rooms[4].puzzle = -1; // 퍼즐 없음
    rooms[4].puzzleSolved = 0; // 퍼즐 없음

    // 아이템 초기화
    // 아이템 0: 검
    items[0].id = 0;
    strcpy(items[0].name, "낡은 검");
    strcpy(items[0].description, "오래되었지만 아직 쓸 만한 검입니다.");
    items[0].damage = 15;
    items[0].healing = 0;

    // 아이템 1: 보물
    items[1].id = 1;
    strcpy(items[1].name, "황금 열쇠");
    strcpy(items[1].description, "반짝이는 황금으로 만든 열쇠입니다.");
    items[1].damage = 0;
    items[1].healing = 0;

    // 아이템 2: 물약
    items[2].id = 2;
    strcpy(items[2].name, "치유 물약");
    strcpy(items[2].description, "마시면 체력을 회복시키는 물약입니다.");
    items[2].damage = 0;
    items[2].healing = 30;

    // 몬스터 초기화
    // 몬스터 0: 고블린
    monsters[0].id = 0;
    strcpy(monsters[0].name, "고블린");
    strcpy(monsters[0].description, "작고 못생긴 고블린입니다.");
    monsters[0].health = 30;
    monsters[0].damage = 5;
    monsters[0].itemDrop = 2; // 물약 드랍

    // 몬스터 1: 보스
    monsters[1].id = 1;
    strcpy(monsters[1].name, "동굴 보스");
    strcpy(monsters[1].description, "거대하고 무서운 동굴 보스입니다.");
    monsters[1].health = 100;
    monsters[1].damage = 15;
    monsters[1].itemDrop = -1; // 아이템 드랍 없음

    printf("
게임이 초기화되었습니다. 모험을 시작하세요!
");
}

// 현재 방 정보 표시 함수
void displayRoom() {
    Room currentRoom = rooms[player.currentRoom];

    printf("
========================================
");
    printf("위치: %s
", currentRoom.name);
    printf("%s
", currentRoom.description);

    // 출구 정보 표시
    printf("출구: ");
    if (currentRoom.exits[0] != -1) printf("북 ");
    if (currentRoom.exits[1] != -1) printf("동 ");
    if (currentRoom.exits[2] != -1) printf("남 ");
    if (currentRoom.exits[3] != -1) printf("서 ");
    printf("
");

    // 아이템 정보 표시
    if (currentRoom.item != -1) {
        printf("아이템: %s - %s
", items[currentRoom.item].name, items[currentRoom.item].description);
    }

    // 몬스터 정보 표시
    if (currentRoom.monster != -1) {
        printf("경고: %s가 있습니다! - %s
", 
               monsters[currentRoom.monster].name, monsters[currentRoom.monster].description);
    }

    // 퍼즐 정보 표시
    if (currentRoom.puzzle != -1 && !currentRoom.puzzleSolved) {
        printf("퍼즐: 이 방에는 해결해야 할 퍼즐이 있습니다.
");
    }

    printf("체력: %d/%d
", player.health, player.maxHealth);
    printf("========================================
");
}

// 플레이어 이동 함수
void movePlayer(int direction) {
    Room currentRoom = rooms[player.currentRoom];
    int nextRoomId = currentRoom.exits[direction];

    if (nextRoomId == -1) {
        printf("그 방향으로는 갈 수 없습니다.
");
        return;
    }

    // 보물 방은 열쇠가 필요
    if (nextRoomId == 2 && player.keys == 0) {
        printf("문이 잠겨 있습니다. 열쇠가 필요합니다.
");
        return;
    }

    // 이동
    player.currentRoom = nextRoomId;
    printf("%s(으)로 이동했습니다.
", 
           direction == 0 ? "북" : 
           direction == 1 ? "동" : 
           direction == 2 ? "남" : "서");

    // 새 방에서의 이벤트 처리
    Room newRoom = rooms[player.currentRoom];

    // 아이템 처리
    if (newRoom.item != -1) {
        handleItem(newRoom.item);
    }

    // 몬스터 처리
    if (newRoom.monster != -1) {
        handleCombat(newRoom.monster);
    }

    // 퍼즐 처리
    if (newRoom.puzzle != -1 && !newRoom.puzzleSolved) {
        handlePuzzle(newRoom.puzzle);
    }
}

// 전투 처리 함수
void handleCombat(int monsterId) {
    Monster monster = monsters[monsterId];
    int playerTurn = 1;
    int choice;

    printf("
========================================
");
    printf("전투 시작!
");
    printf("%s - %s
", monster.name, monster.description);
    printf("체력: %d
", monster.health);
    printf("========================================
");

    // 전투 루프
    while (monster.health > 0 && player.health > 0) {
        if (playerTurn) {
            // 플레이어 턴
            printf("
당신의 턴:
");
            printf("1. 공격
");
            printf("2. 인벤토리 사용
");
            printf("3. 도망
");
            printf("선택: ");
            scanf("%d", &choice);
            clearInputBuffer();

            switch (choice) {
                case 1:
                    // 공격
                    {
                        int damage = player.damage + (rand() % 10 - 5); // 랜덤 데미지 ±5
                        if (damage < 0) damage = 0;
                        
                        printf("%s에게 %d의 데미지를 입혔습니다.
", monster.name, damage);
                        monster.health -= damage;
                        
                        if (monster.health <= 0) {
                            printf("%s를 물리쳤습니다!
", monster.name);
                            
                            // 아이템 드랍
                            if (monster.itemDrop != -1) {
                                printf("%s이(가) %s을(를) 드랍했습니다.
", 
                                       monster.name, items[monster.itemDrop].name);
                                
                                // 인벤토리에 공간이 있는지 확인
                                if (player.inventoryCount < MAX_INVENTORY_SIZE) {
                                    player.inventory[player.inventoryCount] = items[monster.itemDrop];
                                    player.inventoryCount++;
                                } else {
                                    printf("인벤토리가 가득 찼습니다. 아이템을 줍일 수 없습니다.
");
                                }
                            }
                        }
                        break;
                    }
                case 2:
                    // 인벤토리 사용
                    if (player.inventoryCount == 0) {
                        printf("사용할 아이템이 없습니다.
");
                    } else {
                        displayInventory();
                        printf("사용할 아이템 번호를 선택하세요: ");
                        int itemChoice;
                        scanf("%d", &itemChoice);
                        clearInputBuffer();
                        
                        if (itemChoice < 1 || itemChoice > player.inventoryCount) {
                            printf("잘못된 선택입니다.
");
                        } else {
                            itemChoice--; // 배열 인덱스로 변환
                            Item item = player.inventory[itemChoice];
                            
                            if (item.healing > 0) {
                                // 회복 아이템
                                printf("%s을(를) 사용하여 %d의 체력을 회복했습니다.
", 
                                       item.name, item.healing);
                                player.health += item.healing;
                                
                                if (player.health > player.maxHealth) {
                                    player.health = player.maxHealth;
                                }
                                
                                // 인벤토리에서 아이템 제거
                                for (int i = itemChoice; i < player.inventoryCount - 1; i++) {
                                    player.inventory[i] = player.inventory[i + 1];
                                }
                                player.inventoryCount--;
                            } else if (item.damage > 0) {
                                // 공격 아이템
                                int damage = item.damage + (rand() % 10 - 5); // 랜덤 데미지 ±5
                                if (damage < 0) damage = 0;
                                
                                printf("%s으로 %s에게 %d의 데미지를 입혔습니다.
", 
                                       item.name, monster.name, damage);
                                monster.health -= damage;
                                
                                if (monster.health <= 0) {
                                    printf("%s를 물리쳤습니다!
", monster.name);
                                    
                                    // 아이템 드랍
                                    if (monster.itemDrop != -1) {
                                        printf("%s이(가) %s을(를) 드랍했습니다.
", 
                                               monster.name, items[monster.itemDrop].name);
                                        
                                        // 인벤토리에 공간이 있는지 확인
                                        if (player.inventoryCount < MAX_INVENTORY_SIZE) {
                                            player.inventory[player.inventoryCount] = items[monster.itemDrop];
                                            player.inventoryCount++;
                                        } else {
                                            printf("인벤토리가 가득 찼습니다. 아이템을 줍일 수 없습니다.
");
                                        }
                                    }
                                }
                            } else {
                                printf("이 아이템은 전투에서 사용할 수 없습니다.
");
                            }
                        }
                    }
                    break;
                case 3:
                    // 도망
                    if (rand() % 2 == 0) {
                        printf("성공적으로 도망쳤습니다!
");
                        // 이전 방으로 이동
                        player.currentRoom = rooms[player.currentRoom].exits[2]; // 남쪽으로 이동 (가정)
                        return;
                    } else {
                        printf("도망치지 못했습니다!
");
                    }
                    break;
                default:
                    printf("잘못된 선택입니다.
");
            }
            
            playerTurn = 0;
        } else {
            // 몬스터 턴
            printf("
%s의 턴:
", monster.name);
            int damage = monster.damage + (rand() % 5 - 2); // 랜덤 데미지 ±2
            if (damage < 0) damage = 0;
            
            printf("%s이(가) %d의 데미지를 입혔습니다.
", monster.name, damage);
            player.health -= damage;
            
            if (player.health <= 0) {
                printf("당신은 쓰러졌습니다...
");
                gameOver = 1;
            }
            
            playerTurn = 1;
        }
    }
}

// 퍼즐 처리 함수
void handlePuzzle(int puzzleId) {
    int answer;
    
    printf("
========================================
");
    printf("퍼즐을 발견했습니다!
");
    
    switch (puzzleId) {
        case 0:
            // 보물 방 퍼즐
            printf("벽에 다음과 같은 수열이 새겨져 있습니다:
");
            printf("2, 4, 8, 16, ?
");
            printf("다음 숫자는 무엇일까요? ");
            scanf("%d", &answer);
            clearInputBuffer();
            
            if (answer == 32) {
                printf("정답입니다! 퍼즐을 해결했습니다.
");
                rooms[player.currentRoom].puzzleSolved = 1;
                player.keys++; // 열쇠 획득
                printf("보물 상자에서 황금 열쇠를 찾았습니다!
");
            } else {
                printf("오답입니다. 다시 시도해보세요.
");
            }
            break;
            
        case 1:
            // 퍼즐 방 퍼즐
            printf("벽에 다음과 같은 수식이 새겨져 있습니다:
");
            printf("5 + 3 = 28
");
            printf("7 + 5 = 52
");
            printf("9 + 7 = ?
");
            printf("답은 무엇일까요? ");
            scanf("%d", &answer);
            clearInputBuffer();
            
            if (answer == 76) {
                printf("정답입니다! 퍼즐을 해결했습니다.
");
                rooms[player.currentRoom].puzzleSolved = 1;
                player.maxHealth += 20; // 최대 체력 증가
                player.health += 20; // 체력 회복
                printf("신비로운 힘이 당신을 강하게 만들었습니다! 최대 체력이 증가했습니다.
");
            } else {
                printf("오답입니다. 다시 시도해보세요.
");
            }
            break;
            
        default:
            printf("알 수 없는 퍼즐입니다.
");
    }
    
    printf("========================================
");
}

// 아이템 처리 함수
void handleItem(int itemId) {
    Item item = items[itemId];
    
    printf("
%s을(를) 발견했습니다: %s
", item.name, item.description);
    
    // 인벤토리에 공간이 있는지 확인
    if (player.inventoryCount < MAX_INVENTORY_SIZE) {
        printf("인벤토리에 추가했습니다.
");
        player.inventory[player.inventoryCount] = item;
        player.inventoryCount++;
        
        // 방에서 아이템 제거
        rooms[player.currentRoom].item = -1;
        
        // 아이템 효과 즉시 적용
        if (item.damage > 0) {
            player.damage += item.damage;
            printf("공격력이 %d만큼 증가했습니다!
", item.damage);
        }
    } else {
        printf("인벤토리가 가득 찼습니다. 아이템을 줍일 수 없습니다.
");
    }
}

// 게임 저장 함수
void saveGame() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기
    
    if (file == NULL) {
        printf("파일을 열 수 없습니다.
");
        return;
    }
    
    // 플레이어 데이터 저장
    fwrite(&player, sizeof(Player), 1, file);
    
    // 방 데이터 저장
    fwrite(rooms, sizeof(Room), MAX_ROOMS, file);
    
    fclose(file);
    
    printf("게임이 저장되었습니다.
");
}

// 게임 불러오기 함수
void loadGame() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기
    
    if (file == NULL) {
        printf("저장된 게임이 없습니다.
");
        return;
    }
    
    // 플레이어 데이터 불러오기
    fread(&player, sizeof(Player), 1, file);
    
    // 방 데이터 불러오기
    fread(rooms, sizeof(Room), MAX_ROOMS, file);
    
    fclose(file);
    
    printf("%s님의 게임을 불러왔습니다.
", player.name);
}

// 인벤토리 표시 함수
void displayInventory() {
    printf("
========================================
");
    printf("인벤토리:
");
    
    if (player.inventoryCount == 0) {
        printf("비어 있습니다.
");
    } else {
        for (int i = 0; i < player.inventoryCount; i++) {
            printf("%d. %s - %s", i + 1, player.inventory[i].name, player.inventory[i].description);
            
            if (player.inventory[i].damage > 0) {
                printf(" (공격력: +%d)", player.inventory[i].damage);
            }
            
            if (player.inventory[i].healing > 0) {
                printf(" (회복량: +%d)", player.inventory[i].healing);
            }
            
            printf("
");
        }
    }
    
    printf("열쇠: %d개
", player.keys);
    printf("========================================
");
}

// 승리 조건 확인 함수
void checkWinCondition() {
    // 보스를 물리치면 승리
    if (player.currentRoom == 4 && rooms[4].monster == -1) {
        gameWon = 1;
    }
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '\n' && c != EOF);
}

// 유효한 정수 입력 받기 함수
int getValidInt(const char* prompt, int min, int max) {
    int value;
    char input[100];
    
    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);
        
        // 입력된 문자열을 정수로 변환
        if (sscanf(input, "%d", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %d에서 %d 사이의 값을 입력하세요.
", min, max);
            }
        } else {
            printf("오류: 유효한 정수를 입력하세요.
");
        }
    }
} 공격
                    int damage = player.damage;

                    // 무기 아이템이 있으면 추가 공격력
                    for (int i = 0; i < player.inventoryCount; i++) {
                        if (player.inventory[i].damage > 0) {
                            damage += player.inventory[i].damage;
                            break;
                        }
                    }

                    monster.health -= damage;
                    printf("당신은 %s에게 %d의 피해를 입혔습니다.
", monster.name, damage);

                    if (monster.health <= 0) {
                        printf("%s를 물리쳤습니다!
", monster.name);

                        // 아이템 드랍
                        if (monster.itemDrop != -1) {
                            printf("%s가 %s을(를) 떨어뜨렸습니다.
", 
                                   monster.name, items[monster.itemDrop].name);

                            // 인벤토리에 아이템 추가
                            if (player.inventoryCount < MAX_INVENTORY_SIZE) {
                                player.inventory[player.inventoryCount] = items[monster.itemDrop];
                                player.inventoryCount++;
                            } else {
                                printf("인벤토리가 꽉 차서 아이템을 줍을 수 없습니다.
");
                            }
                        }
                    }
                    break;

                case 2:
                    // 인벤토리 사용
                    displayInventory();

                    if (player.inventoryCount > 0) {
                        printf("사용할 아이템 번호를 선택하세요 (0-%d): ", player.inventoryCount - 1);
                        int itemIndex;
                        scanf("%d", &itemIndex);
                        clearInputBuffer();

                        if (itemIndex >= 0 && itemIndex < player.inventoryCount) {
                            Item item = player.inventory[itemIndex];

                            if (item.healing > 0) {
                                // 회복 아이템
                                player.health += item.healing;
                                if (player.health > player.maxHealth) {
                                    player.health = player.maxHealth;
                                }

                                printf("%s을(를) 사용하여 체력을 %d 회복했습니다.
", 
                                       item.name, item.healing);

                                // 사용한 아이템 제거
                                for (int i = itemIndex; i < player.inventoryCount - 1; i++) {
                                    player.inventory[i] = player.inventory[i + 1];
                                }
                                player.inventoryCount--;
                            } else {
                                printf("전투 중에는 사용할 수 없는 아이템입니다.
");
                            }
                        } else {
                            printf("잘못된 선택입니다.
");
                        }
                    } else {
                        printf("사용할 아이템이 없습니다.
");
                    }
                    break;

                case 3:
                    // 도망
                    int escapeChance = rand() % 100;

                    if (escapeChance < 50) {
                        printf("도망에 성공했습니다!
");
                        player.currentRoom = rooms[player.currentRoom].exits[rand() % 4];
                        return;
                    } else {
                        printf("도망에 실패했습니다!
");
                    }
                    break;

                default:
                    printf("잘못된 선택입니다.
");
            }
        } else {
            // 몬스터 턴
            int damage = monster.damage;
            player.health -= damage;
            printf("%s이(가) 당신에게 %d의 피해를 입혔습니다.
", monster.name, damage);

            if (player.health <= 0) {
                printf("당신은 쓰러졌습니다...
");
                gameOver = 1;
            }
        }

        playerTurn = !playerTurn; // 턴 교체
    }

    printf("========================================
");
}

// 퍼즐 처리 함수
void handlePuzzle(int puzzleId) {
    int solved = 0;
    int answer;

    printf("
========================================
");
    printf("퍼즐 발견!
");

    switch (puzzleId) {
        case 0:
            // 숫자 퍼즐
            printf("다음 수열의 다음 숫자는 무엇일까요?
");
            printf("1, 1, 2, 3, 5, 8, ?
");
            printf("정답: ");
            scanf("%d", &answer);
            clearInputBuffer();

            if (answer == 13) { // 피보나치 수열
                solved = 1;
                printf("정답입니다! 퍼즐을 해결했습니다.
");
            } else {
                printf("오답입니다. 다시 시도하세요.
");
            }
            break;

        case 1:
            // 논리 퍼즐
            printf("다음 중 참인 것은 무엇일까요?
");
            printf("1. 모든 개는 동물이다.
");
            printf("2. 어떤 개는 동물이 아니다.
");
            printf("3. 결론: ?
");
            printf("정답 (1-3): ");
            scanf("%d", &answer);
            clearInputBuffer();

            if (answer == 1) { // 모든 개는 동물이다
                solved = 1;
                printf("정답입니다! 퍼즐을 해결했습니다.
");
            } else {
                printf("오답입니다. 다시 시도하세요.
");
            }
            break;

        default:
            printf("알 수 없는 퍼즐입니다.
");
            return;
    }

    if (solved) {
        rooms[player.currentRoom].puzzleSolved = 1;

        // 퍼즐 보상
        if (puzzleId == 0) {
            printf("보물 상자가 열렸습니다!
");

            // 인벤토리에 아이템 추가
            if (player.inventoryCount < MAX_INVENTORY_SIZE) {
                player.inventory[player.inventoryCount] = items[2]; // 물약
                player.inventoryCount++;
            } else {
                printf("인벤토리가 꽉 차서 아이템을 줍을 수 없습니다.
");
            }
        }
    }

    printf("========================================
");
}

// 아이템 처리 함수
void handleItem(int itemId) {
    Item item = items[itemId];

    printf("
========================================
");
    printf("아이템 발견!
");
    printf("%s - %s
", item.name, item.description);

    // 아이템 획득
    if (player.inventoryCount < MAX_INVENTORY_SIZE) {
        player.inventory[player.inventoryCount] = item;
        player.inventoryCount++;

        // 아이템 획득 효과
        if (item.damage > 0) {
            printf("무기 공격력이 +%d 증가했습니다.
", item.damage);
        }

        if (strcmp(item.name, "황금 열쇠") == 0) {
            player.keys++;
            printf("열쇠를 획득했습니다.
");
        }

        // 방에서 아이템 제거
        rooms[player.currentRoom].item = -1;

        printf("아이템을 획득했습니다.
");
    } else {
        printf("인벤토리가 꽉 차서 아이템을 줍을 수 없습니다.
");
    }

    printf("========================================
");
}

// 게임 저장 함수
void saveGame() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기

    if (file == NULL) {
        printf("파일을 열 수 없습니다.
");
        return;
    }

    // 플레이어 데이터 저장
    fwrite(&player, sizeof(Player), 1, file);

    // 방 데이터 저장
    fwrite(rooms, sizeof(Room), MAX_ROOMS, file);

    fclose(file);

    printf("게임이 저장되었습니다.
");
}

// 게임 불러오기 함수
void loadGame() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기

    if (file == NULL) {
        printf("저장된 게임이 없습니다. 새 게임을 시작합니다.
");
        initGame();
        return;
    }

    // 플레이어 데이터 불러오기
    fread(&player, sizeof(Player), 1, file);

    // 방 데이터 불러오기
    fread(rooms, sizeof(Room), MAX_ROOMS, file);

    fclose(file);

    printf("%s님의 게임을 불러왔습니다.
", player.name);
}

// 인벤토리 표시 함수
void displayInventory() {
    printf("
========================================
");
    printf("인벤토리:
");

    if (player.inventoryCount == 0) {
        printf("비어 있습니다.
");
    } else {
        for (int i = 0; i < player.inventoryCount; i++) {
            printf("%d. %s - %s
", i, 
                   player.inventory[i].name, player.inventory[i].description);
        }
    }

    printf("열쇠: %d개
", player.keys);
    printf("========================================
");
}

// 승리 조건 확인 함수
void checkWinCondition() {
    // 보스를 물리치면 승리
    if (player.currentRoom == 4 && rooms[4].monster == -1) {
        gameWon = 1;
    }
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '
' && c != EOF);
}
