/*
 * 간단한 은행 계좌 관리 시스템
 *
 * 이 프로그램은 은행 계좌를 관리하는 간단한 콘솔 기반 프로그램입니다.
 * 계좌 생성, 조회, 입금, 출금, 이체 등의 기본적인 은행 업무를 수행할 수 있습니다.
 *
 * 작성자: 코딩 쏙 학원
 * 날짜: 2023-11-01
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <ctype.h>

// 상수 정의
#define MAX_ACCOUNTS 100       // 최대 계좌 수
#define MAX_NAME_LENGTH 50      // 최대 이름 길이
#define MAX_PASSWORD_LENGTH 20    // 최대 비밀번호 길이
#define MAX_TRANSACTIONS 50    // 최대 거래 내역 수
#define FILENAME "accounts.dat"  // 데이터 파일 이름

// 거래 유형 정의
typedef enum {
    DEPOSIT,    // 입금
    WITHDRAWAL, // 출금
    TRANSFER    // 이체
} TransactionType;

// 거래 내역 구조체 정의
typedef struct {
    time_t date;               // 거래 일자
    TransactionType type;       // 거래 유형
    double amount;             // 거래 금액
    char description[100];      // 거래 설명
    int toAccount;            // 이체 대상 계좌 (이체 시에만 사용)
} Transaction;

// 계좌 구조체 정의
typedef struct {
    int accountNumber;                 // 계좌번호
    char ownerName[MAX_NAME_LENGTH];   // 예금주 이름
    char password[MAX_PASSWORD_LENGTH]; // 비밀번호
    double balance;                  // 잔액
    Transaction transactions[MAX_TRANSACTIONS]; // 거래 내역 배열
    int transactionCount;             // 거래 내역 수
} Account;

// 전역 변수
Account accounts[MAX_ACCOUNTS]; // 계좌 배열
int accountCount = 0;          // 현재 계좌 수
int currentAccountIndex = -1;  // 현재 로그인한 계좌 인덱스

// 함수 선언
void displayMenu();
void createAccount();
void displayAllAccounts();
void searchAccount();
void login();
void logout();
void deposit();
void withdraw();
void transfer();
void updateAccount();
void displayTransactions();
void saveToFile();
void loadFromFile();
void clearInputBuffer();
int findAccountIndex(int accountNumber);
int getValidInt(const char* prompt, int min, int max);
double getValidDouble(const char* prompt, double min, double max);

// 메인 함수
int main() {
    int choice;

    // 프로그램 시작 시 파일에서 데이터 로드
    loadFromFile();

    printf("========================================
");
    printf("        은행 계좌 관리 시스템
");
    printf("========================================
");

    do {
        // 로그인 상태에 따라 다른 메뉴 표시
        if (currentAccountIndex == -1) {
            // 비로그인 상태 메뉴
            printf("
1. 계좌 생성
");
            printf("2. 계좌 조회
");
            printf("3. 로그인
");
            printf("4. 종료
");
            printf("========================================
");
            printf("메뉴를 선택하세요: ");
            scanf("%d", &choice);
            clearInputBuffer();

            switch (choice) {
                case 1:
                    createAccount();
                    break;
                case 2:
                    displayAllAccounts();
                    break;
                case 3:
                    login();
                    break;
                case 4:
                    printf("프로그램을 종료합니다.
");
                    break;
                default:
                    printf("잘못된 선택입니다. 다시 시도하세요.
");
            }
        } else {
            // 로그인 상태 메뉴
            printf("
1. 입금
");
            printf("2. 출금
");
            printf("3. 이체
");
            printf("4. 계좌 정보 수정
");
            printf("5. 거래 내역 조회
");
            printf("6. 로그아웃
");
            printf("========================================
");
            printf("메뉴를 선택하세요: ");
            scanf("%d", &choice);
            clearInputBuffer();

            switch (choice) {
                case 1:
                    deposit();
                    break;
                case 2:
                    withdraw();
                    break;
                case 3:
                    transfer();
                    break;
                case 4:
                    updateAccount();
                    break;
                case 5:
                    displayTransactions();
                    break;
                case 6:
                    logout();
                    break;
                default:
                    printf("잘못된 선택입니다. 다시 시도하세요.
");
            }
        }

        if ((currentAccountIndex == -1 && choice != 4) || 
            (currentAccountIndex != -1 && choice != 6)) {
            printf("
계속하려면 Enter 키를 누르세요...");
            clearInputBuffer();
            getchar(); // Enter 키 입력 대기
        }
    } while ((currentAccountIndex == -1 && choice != 4) || 
             (currentAccountIndex != -1 && choice != 6));

    // 프로그램 종료 시 데이터 저장
    saveToFile();

    return 0;
}

// 메뉴 표시 함수
void displayMenu() {
    printf("========================================
");
    printf("                메뉴
");
    printf("========================================
");
}

// 계좌 생성 함수
void createAccount() {
    if (accountCount >= MAX_ACCOUNTS) {
        printf("최대 계좌 수에 도달했습니다. 더 이상 생성할 수 없습니다.
");
        return;
    }

    Account newAccount;

    printf("
=== 계좌 생성 ===
");

    // 계좌번호 생성 (랜덤)
    int accountNumber;
    do {
        accountNumber = 100000 + rand() % 900000; // 100000-999999 사이의 랜덤 번호

        // 중복 확인
        if (findAccountIndex(accountNumber) == -1) {
            break;
        }
    } while (1);

    newAccount.accountNumber = accountNumber;

    // 예금주 이름 입력
    printf("예금주 이름: ");
    fgets(newAccount.ownerName, MAX_NAME_LENGTH, stdin);
    newAccount.ownerName[strcspn(newAccount.ownerName, "
")] = ''; // 개행 문자 제거

    // 비밀번호 입력
    printf("비밀번호: ");
    fgets(newAccount.password, MAX_PASSWORD_LENGTH, stdin);
    newAccount.password[strcspn(newAccount.password, "
")] = '';

    // 초기 잔액 입력
    newAccount.balance = getValidDouble("초기 입금액: ", 0, 10000000);

    // 거래 내역 초기화
    newAccount.transactionCount = 0;

    // 계좌 배열에 추가
    accounts[accountCount] = newAccount;
    accountCount++;

    printf("
계좌가 생성되었습니다.
");
    printf("계좌번호: %d
", newAccount.accountNumber);
    printf("예금주: %s
", newAccount.ownerName);
    printf("초기 잔액: %.2f원
", newAccount.balance);

    // 초기 입금 거래 내역 추가
    Transaction initialDeposit;
    time(&initialDeposit.date);
    initialDeposit.type = DEPOSIT;
    initialDeposit.amount = newAccount.balance;
    strcpy(initialDeposit.description, "초기 입금");
    initialDeposit.toAccount = -1;

    accounts[accountCount - 1].transactions[0] = initialDeposit;
    accounts[accountCount - 1].transactionCount = 1;
}

// 전체 계좌 조회 함수
void displayAllAccounts() {
    if (accountCount == 0) {
        printf("등록된 계좌가 없습니다.
");
        return;
    }

    printf("
=== 전체 계좌 목록 ===
");
    printf("========================================================================
");
    printf(" 계좌번호	예금주		잔액
");
    printf("========================================================================
");

    for (int i = 0; i < accountCount; i++) {
        printf(" %d	%s		%.2f원
", 
               accounts[i].accountNumber, accounts[i].ownerName, accounts[i].balance);
    }

    printf("========================================================================
");
    printf("총 계좌 수: %d
", accountCount);
}

// 계좌 검색 함수
void searchAccount() {
    if (accountCount == 0) {
        printf("등록된 계좌가 없습니다.
");
        return;
    }

    int accountNumber;
    int index;

    printf("
=== 계좌 검색 ===
");
    accountNumber = getValidInt("검색할 계좌번호를 입력하세요: ", 100000, 999999);

    // 계좌 인덱스 찾기
    index = findAccountIndex(accountNumber);

    if (index == -1) {
        printf("계좌번호 %d인 계좌를 찾을 수 없습니다.
", accountNumber);
    } else {
        printf("
계좌 정보:
");
        printf("계좌번호: %d
", accounts[index].accountNumber);
        printf("예금주: %s
", accounts[index].ownerName);
        printf("잔액: %.2f원
", accounts[index].balance);
    }
}

// 로그인 함수
void login() {
    if (accountCount == 0) {
        printf("등록된 계좌가 없습니다.
");
        return;
    }

    int accountNumber;
    char password[MAX_PASSWORD_LENGTH];
    int index;
    int attempts = 0;
    const int maxAttempts = 3;

    printf("
=== 로그인 ===
");

    do {
        accountNumber = getValidInt("계좌번호: ", 100000, 999999);

        // 계좌 인덱스 찾기
        index = findAccountIndex(accountNumber);

        if (index == -1) {
            printf("계좌번호 %d인 계좌를 찾을 수 없습니다.
", accountNumber);
            attempts++;
            continue;
        }

        printf("비밀번호: ");
        fgets(password, MAX_PASSWORD_LENGTH, stdin);
        password[strcspn(password, "
")] = '';

        // 비밀번호 확인
        if (strcmp(accounts[index].password, password) == 0) {
            currentAccountIndex = index;
            printf("
%s님, 환영합니다!
", accounts[index].ownerName);
            printf("계좌번호: %d
", accounts[index].accountNumber);
            printf("현재 잔액: %.2f원
", accounts[index].balance);
            return;
        } else {
            printf("비밀번호가 일치하지 않습니다.
");
            attempts++;
        }
    } while (attempts < maxAttempts);

    if (attempts >= maxAttempts) {
        printf("로그인 시도 횟수를 초과했습니다. 나중에 다시 시도하세요.
");
    }
}

// 로그아웃 함수
void logout() {
    if (currentAccountIndex == -1) {
        printf("로그인되어 있지 않습니다.
");
        return;
    }

    printf("
%s님, 로그아웃되었습니다.
", accounts[currentAccountIndex].ownerName);
    currentAccountIndex = -1;
}

// 입금 함수
void deposit() {
    if (currentAccountIndex == -1) {
        printf("로그인되어 있지 않습니다.
");
        return;
    }

    double amount;

    printf("
=== 입금 ===
");
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);

    amount = getValidDouble("입금액: ", 0, 10000000);

    // 잔액 업데이트
    accounts[currentAccountIndex].balance += amount;

    // 거래 내역 추가
    Transaction transaction;
    time(&transaction.date);
    transaction.type = DEPOSIT;
    transaction.amount = amount;
    strcpy(transaction.description, "입금");
    transaction.toAccount = -1;

    // 거래 내역 배열에 추가
    if (accounts[currentAccountIndex].transactionCount < MAX_TRANSACTIONS) {
        accounts[currentAccountIndex].transactions[accounts[currentAccountIndex].transactionCount] = transaction;
        accounts[currentAccountIndex].transactionCount++;
    } else {
        // 배열이 가득 찼으면 가장 오래된 거래 삭제하고 새 거래 추가
        for (int i = 0; i < MAX_TRANSACTIONS - 1; i++) {
            accounts[currentAccountIndex].transactions[i] = accounts[currentAccountIndex].transactions[i + 1];
        }
        accounts[currentAccountIndex].transactions[MAX_TRANSACTIONS - 1] = transaction;
    }

    printf("%.2f원이 입금되었습니다.
", amount);
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);
}

// 출금 함수
void withdraw() {
    if (currentAccountIndex == -1) {
        printf("로그인되어 있지 않습니다.
");
        return;
    }

    double amount;
    char password[MAX_PASSWORD_LENGTH];

    printf("
=== 출금 ===
");
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);

    amount = getValidDouble("출금액: ", 0, accounts[currentAccountIndex].balance);

    // 비밀번호 확인
    printf("비밀번호 확인: ");
    fgets(password, MAX_PASSWORD_LENGTH, stdin);
    password[strcspn(password, "
")] = '';

    if (strcmp(accounts[currentAccountIndex].password, password) != 0) {
        printf("비밀번호가 일치하지 않습니다.
");
        return;
    }

    // 잔액 업데이트
    accounts[currentAccountIndex].balance -= amount;

    // 거래 내역 추가
    Transaction transaction;
    time(&transaction.date);
    transaction.type = WITHDRAWAL;
    transaction.amount = amount;
    strcpy(transaction.description, "출금");
    transaction.toAccount = -1;

    // 거래 내역 배열에 추가
    if (accounts[currentAccountIndex].transactionCount < MAX_TRANSACTIONS) {
        accounts[currentAccountIndex].transactions[accounts[currentAccountIndex].transactionCount] = transaction;
        accounts[currentAccountIndex].transactionCount++;
    } else {
        // 배열이 가득 찼으면 가장 오래된 거래 삭제하고 새 거래 추가
        for (int i = 0; i < MAX_TRANSACTIONS - 1; i++) {
            accounts[currentAccountIndex].transactions[i] = accounts[currentAccountIndex].transactions[i + 1];
        }
        accounts[currentAccountIndex].transactions[MAX_TRANSACTIONS - 1] = transaction;
    }

    printf("%.2f원이 출금되었습니다.
", amount);
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);
}

// 이체 함수
void transfer() {
    if (currentAccountIndex == -1) {
        printf("로그인되어 있지 않습니다.
");
        return;
    }

    int toAccountNumber;
    int toAccountIndex;
    double amount;
    char password[MAX_PASSWORD_LENGTH];

    printf("
=== 이체 ===
");
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);

    // 이체 대상 계좌 입력
    toAccountNumber = getValidInt("이체할 계좌번호: ", 100000, 999999);

    // 계좌 인덱스 찾기
    toAccountIndex = findAccountIndex(toAccountNumber);

    if (toAccountIndex == -1) {
        printf("계좌번호 %d인 계좌를 찾을 수 없습니다.
", toAccountNumber);
        return;
    }

    if (toAccountIndex == currentAccountIndex) {
        printf("자기 자신에게 이체할 수 없습니다.
");
        return;
    }

    amount = getValidDouble("이체금액: ", 0, accounts[currentAccountIndex].balance);

    // 비밀번호 확인
    printf("비밀번호 확인: ");
    fgets(password, MAX_PASSWORD_LENGTH, stdin);
    password[strcspn(password, "
")] = '';

    if (strcmp(accounts[currentAccountIndex].password, password) != 0) {
        printf("비밀번호가 일치하지 않습니다.
");
        return;
    }

    // 잔액 업데이트
    accounts[currentAccountIndex].balance -= amount;
    accounts[toAccountIndex].balance += amount;

    // 보내는 계좌 거래 내역 추가
    Transaction transactionFrom;
    time(&transactionFrom.date);
    transactionFrom.type = TRANSFER;
    transactionFrom.amount = amount;
    sprintf(transactionFrom.description, "이체 (계좌번호: %d)", toAccountNumber);
    transactionFrom.toAccount = toAccountNumber;

    // 받는 계좌 거래 내역 추가
    Transaction transactionTo;
    time(&transactionTo.date);
    transactionTo.type = DEPOSIT;
    transactionTo.amount = amount;
    sprintf(transactionTo.description, "이체 입금 (계좌번호: %d)", accounts[currentAccountIndex].accountNumber);
    transactionTo.toAccount = -1;

    // 보내는 계좌 거래 내역 배열에 추가
    if (accounts[currentAccountIndex].transactionCount < MAX_TRANSACTIONS) {
        accounts[currentAccountIndex].transactions[accounts[currentAccountIndex].transactionCount] = transactionFrom;
        accounts[currentAccountIndex].transactionCount++;
    } else {
        // 배열이 가득 찼으면 가장 오래된 거래 삭제하고 새 거래 추가
        for (int i = 0; i < MAX_TRANSACTIONS - 1; i++) {
            accounts[currentAccountIndex].transactions[i] = accounts[currentAccountIndex].transactions[i + 1];
        }
        accounts[currentAccountIndex].transactions[MAX_TRANSACTIONS - 1] = transactionFrom;
    }

    // 받는 계좌 거래 내역 배열에 추가
    if (accounts[toAccountIndex].transactionCount < MAX_TRANSACTIONS) {
        accounts[toAccountIndex].transactions[accounts[toAccountIndex].transactionCount] = transactionTo;
        accounts[toAccountIndex].transactionCount++;
    } else {
        // 배열이 가득 찼으면 가장 오래된 거래 삭제하고 새 거래 추가
        for (int i = 0; i < MAX_TRANSACTIONS - 1; i++) {
            accounts[toAccountIndex].transactions[i] = accounts[toAccountIndex].transactions[i + 1];
        }
        accounts[toAccountIndex].transactions[MAX_TRANSACTIONS - 1] = transactionTo;
    }

    printf("%.2f원이 계좌번호 %d(으)로 이체되었습니다.
", amount, toAccountNumber);
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);
}

// 계좌 정보 수정 함수
void updateAccount() {
    if (currentAccountIndex == -1) {
        printf("로그인되어 있지 않습니다.
");
        return;
    }

    char oldPassword[MAX_PASSWORD_LENGTH];
    char newPassword[MAX_PASSWORD_LENGTH];
    char newName[MAX_NAME_LENGTH];
    int choice;

    printf("
=== 계좌 정보 수정 ===
");
    printf("현재 계좌 정보:
");
    printf("계좌번호: %d
", accounts[currentAccountIndex].accountNumber);
    printf("예금주: %s
", accounts[currentAccountIndex].ownerName);
    printf("잔액: %.2f원
", accounts[currentAccountIndex].balance);

    // 기존 비밀번호 확인
    printf("기존 비밀번호: ");
    fgets(oldPassword, MAX_PASSWORD_LENGTH, stdin);
    oldPassword[strcspn(oldPassword, "
")] = '';

    if (strcmp(accounts[currentAccountIndex].password, oldPassword) != 0) {
        printf("비밀번호가 일치하지 않습니다.
");
        return;
    }

    printf("
수정할 정보를 선택하세요:
");
    printf("1. 비밀번호
");
    printf("2. 예금주 이름
");
    printf("3. 취소
");
    printf("선택: ");
    scanf("%d", &choice);
    clearInputBuffer();

    switch (choice) {
        case 1:
            // 비밀번호 수정
            printf("새 비밀번호: ");
            fgets(newPassword, MAX_PASSWORD_LENGTH, stdin);
            newPassword[strcspn(newPassword, "
")] = '';

            // 비밀번호 확인
            printf("새 비밀번호 확인: ");
            char confirmPassword[MAX_PASSWORD_LENGTH];
            fgets(confirmPassword, MAX_PASSWORD_LENGTH, stdin);
            confirmPassword[strcspn(confirmPassword, "
")] = '';

            if (strcmp(newPassword, confirmPassword) == 0) {
                strcpy(accounts[currentAccountIndex].password, newPassword);
                printf("비밀번호가 변경되었습니다.
");
            } else {
                printf("새 비밀번호가 일치하지 않습니다.
");
            }
            break;

        case 2:
            // 예금주 이름 수정
            printf("새 예금주 이름: ");
            fgets(newName, MAX_NAME_LENGTH, stdin);
            newName[strcspn(newName, "
")] = '';

            if (strlen(newName) > 0) {
                strcpy(accounts[currentAccountIndex].ownerName, newName);
                printf("예금주 이름이 변경되었습니다.
");
            }
            break;

        case 3:
            printf("수정이 취소되었습니다.
");
            break;

        default:
            printf("잘못된 선택입니다.
");
    }
}

// 거래 내역 조회 함수
void displayTransactions() {
    if (currentAccountIndex == -1) {
        printf("로그인되어 있지 않습니다.
");
        return;
    }

    if (accounts[currentAccountIndex].transactionCount == 0) {
        printf("거래 내역이 없습니다.
");
        return;
    }

    printf("
=== 거래 내역 ===
");
    printf("========================================================================
");
    printf(" 일자		유형		금액		설명
");
    printf("========================================================================
");

    // 최신 거래부터 표시
    for (int i = accounts[currentAccountIndex].transactionCount - 1; i >= 0; i--) {
        Transaction transaction = accounts[currentAccountIndex].transactions[i];

        // 날짜 형식 변환
        char dateStr[20];
        strftime(dateStr, sizeof(dateStr), "%Y-%m-%d", localtime(&transaction.date));

        // 거래 유형에 따른 표시
        char typeStr[20];
        switch (transaction.type) {
            case DEPOSIT:
                strcpy(typeStr, "입금");
                break;
            case WITHDRAWAL:
                strcpy(typeStr, "출금");
                break;
            case TRANSFER:
                strcpy(typeStr, "이체");
                break;
        }

        printf(" %s	%s	%.2f원	%s
", 
               dateStr, typeStr, transaction.amount, transaction.description);
    }

    printf("========================================================================
");
    printf("현재 잔액: %.2f원
", accounts[currentAccountIndex].balance);
}

// 파일에 데이터 저장 함수
void saveToFile() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기

    if (file == NULL) {
        printf("파일을 열 수 없습니다.
");
        return;
    }

    // 계좌 수 저장
    fwrite(&accountCount, sizeof(int), 1, file);

    // 계좌 데이터 저장
    fwrite(accounts, sizeof(Account), accountCount, file);

    fclose(file);

    printf("%d개의 계좌 정보가 파일에 저장되었습니다.
", accountCount);
}

// 파일에서 데이터 불러오기 함수
void loadFromFile() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기

    if (file == NULL) {
        printf("데이터 파일이 없거나 열 수 없습니다.
");
        return;
    }

    // 계좌 수 불러오기
    fread(&accountCount, sizeof(int), 1, file);

    // 계좌 데이터 불러오기
    fread(accounts, sizeof(Account), accountCount, file);

    fclose(file);

    printf("%d개의 계좌 정보를 파일에서 불러왔습니다.
", accountCount);
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '
' && c != EOF);
}

// 계좌 인덱스 찾기 함수
int findAccountIndex(int accountNumber) {
    for (int i = 0; i < accountCount; i++) {
        if (accounts[i].accountNumber == accountNumber) {
            return i;
        }
    }
    return -1; // 찾지 못한 경우
}

// 유효한 정수 입력 받기 함수
int getValidInt(const char* prompt, int min, int max) {
    int value;
    char input[100];

    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);

        // 입력된 문자열을 정수로 변환
        if (sscanf(input, "%d", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %d에서 %d 사이의 값을 입력하세요.
", min, max);
            }
        } else {
            printf("오류: 유효한 정수를 입력하세요.
");
        }
    }
}

// 유효한 실수 입력 받기 함수
double getValidDouble(const char* prompt, double min, double max) {
    double value;
    char input[100];

    while (1) {
        printf("%s", prompt);
        fgets(input, sizeof(input), stdin);

        // 입력된 문자열을 실수로 변환
        if (sscanf(input, "%lf", &value) == 1) {
            // 입력된 값이 유효한 범위 내에 있는지 확인
            if (value >= min && value <= max) {
                return value;
            } else {
                printf("오류: %.2f에서 %.2f 사이의 값을 입력하세요.
", min, max);
            }
        } else {
            printf("오류: 유효한 숫자를 입력하세요.
");
        }
    }
}
