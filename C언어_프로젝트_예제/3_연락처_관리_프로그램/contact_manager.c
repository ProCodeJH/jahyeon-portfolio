/*
 * 연락처 관리 프로그램
 *
 * 이 프로그램은 연락처 정보를 추가, 조회, 수정, 삭제하고 검색하는
 * 콘솔 기반 연락처 관리 프로그램입니다.
 *
 * 작성자: 코딩 쏙 학원
 * 날짜: 2023-11-01
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <ctype.h>

// 상수 정의
#define MAX_NAME_LENGTH 50      // 최대 이름 길이
#define MAX_PHONE_LENGTH 15     // 최대 전화번호 길이
#define MAX_EMAIL_LENGTH 50     // 최대 이메일 길이
#define MAX_ADDRESS_LENGTH 100   // 최대 주소 길이
#define FILENAME "contacts.dat"  // 데이터 파일 이름

// 연락처 구조체 정의
typedef struct {
    char name[MAX_NAME_LENGTH];     // 이름
    char phone[MAX_PHONE_LENGTH];   // 전화번호
    char email[MAX_EMAIL_LENGTH];   // 이메일
    char address[MAX_ADDRESS_LENGTH]; // 주소
} Contact;

// 전역 변수
Contact* contacts = NULL;  // 연락처 배열 (동적 할당)
int contactCount = 0;       // 현재 연락처 수
int capacity = 10;          // 현재 배열 용량

// 함수 선언
void displayMenu();
void addContact();
void displayAllContacts();
void searchContact();
void updateContact();
void deleteContact();
void sortContacts();
void saveToFile();
void loadFromFile();
void clearInputBuffer();
void resizeArray();
int findContactIndex(const char* name);
int findContactByPhone(const char* phone);
void printContact(int index);

// 메인 함수
int main() {
    int choice;

    // 프로그램 시작 시 파일에서 데이터 로드
    loadFromFile();

    printf("========================================
");
    printf("         연락처 관리 프로그램
");
    printf("========================================
");

    do {
        displayMenu();
        printf("메뉴를 선택하세요: ");
        scanf("%d", &choice);
        clearInputBuffer();

        switch (choice) {
            case 1:
                addContact();
                break;
            case 2:
                displayAllContacts();
                break;
            case 3:
                searchContact();
                break;
            case 4:
                updateContact();
                break;
            case 5:
                deleteContact();
                break;
            case 6:
                sortContacts();
                break;
            case 7:
                saveToFile();
                break;
            case 8:
                loadFromFile();
                break;
            case 9:
                printf("프로그램을 종료합니다.
");
                break;
            default:
                printf("잘못된 선택입니다. 다시 시도하세요.
");
        }

        if (choice != 9) {
            printf("
계속하려면 Enter 키를 누르세요...");
            clearInputBuffer();
            getchar(); // Enter 키 입력 대기
            printf("
");
        }
    } while (choice != 9);

    // 프로그램 종료 시 데이터 저장
    saveToFile();

    // 동적 할당된 메모리 해제
    free(contacts);

    return 0;
}

// 메뉴 표시 함수
void displayMenu() {
    printf("========================================
");
    printf("                메뉴
");
    printf("========================================
");
    printf("1. 연락처 추가
");
    printf("2. 전체 연락처 조회
");
    printf("3. 연락처 검색
");
    printf("4. 연락처 수정
");
    printf("5. 연락처 삭제
");
    printf("6. 연락처 정렬
");
    printf("7. 데이터 저장
");
    printf("8. 데이터 불러오기
");
    printf("9. 종료
");
    printf("========================================
");
}

// 연락처 추가 함수
void addContact() {
    // 배열 용량 확인 및 필요시 확장
    if (contactCount >= capacity) {
        resizeArray();
    }

    Contact newContact;

    printf("
=== 연락처 추가 ===
");

    // 이름 입력
    printf("이름: ");
    fgets(newContact.name, MAX_NAME_LENGTH, stdin);
    newContact.name[strcspn(newContact.name, "
")] = ''; // 개행 문자 제거

    // 전화번호 입력
    printf("전화번호: ");
    fgets(newContact.phone, MAX_PHONE_LENGTH, stdin);
    newContact.phone[strcspn(newContact.phone, "
")] = '';

    // 이메일 입력
    printf("이메일: ");
    fgets(newContact.email, MAX_EMAIL_LENGTH, stdin);
    newContact.email[strcspn(newContact.email, "
")] = '';

    // 주소 입력
    printf("주소: ");
    fgets(newContact.address, MAX_ADDRESS_LENGTH, stdin);
    newContact.address[strcspn(newContact.address, "
")] = '';

    // 연락처 배열에 추가
    contacts[contactCount] = newContact;
    contactCount++;

    printf("연락처가 추가되었습니다.
");
}

// 전체 연락처 조회 함수
void displayAllContacts() {
    if (contactCount == 0) {
        printf("저장된 연락처가 없습니다.
");
        return;
    }

    printf("
=== 전체 연락처 목록 ===
");
    printf("========================================================================================================
");
    printf(" 번호	이름		전화번호	이메일			주소
");
    printf("========================================================================================================
");

    for (int i = 0; i < contactCount; i++) {
        printf(" %d	%s		%s	%s		%s
",
               i + 1, contacts[i].name, contacts[i].phone, contacts[i].email, contacts[i].address);
    }

    printf("========================================================================================================
");
    printf("총 연락처 수: %d
", contactCount);
}

// 연락처 검색 함수
void searchContact() {
    if (contactCount == 0) {
        printf("저장된 연락처가 없습니다.
");
        return;
    }

    int choice;
    char searchTerm[MAX_NAME_LENGTH];
    int foundCount = 0;

    printf("
=== 연락처 검색 ===
");
    printf("1. 이름으로 검색
");
    printf("2. 전화번호로 검색
");
    printf("검색 방법을 선택하세요: ");
    scanf("%d", &choice);
    clearInputBuffer();

    switch (choice) {
        case 1:
            printf("검색할 이름을 입력하세요: ");
            fgets(searchTerm, MAX_NAME_LENGTH, stdin);
            searchTerm[strcspn(searchTerm, "
")] = '';

            printf("
검색 결과:
");
            printf("========================================================================================================
");
            printf(" 번호	이름		전화번호	이메일			주소
");
            printf("========================================================================================================
");

            for (int i = 0; i < contactCount; i++) {
                if (strstr(contacts[i].name, searchTerm) != NULL) {
                    printf(" %d	%s		%s	%s		%s
",
                           i + 1, contacts[i].name, contacts[i].phone, contacts[i].email, contacts[i].address);
                    foundCount++;
                }
            }
            break;

        case 2:
            printf("검색할 전화번호를 입력하세요: ");
            fgets(searchTerm, MAX_PHONE_LENGTH, stdin);
            searchTerm[strcspn(searchTerm, "
")] = '';

            printf("
검색 결과:
");
            printf("========================================================================================================
");
            printf(" 번호	이름		전화번호	이메일			주소
");
            printf("========================================================================================================
");

            for (int i = 0; i < contactCount; i++) {
                if (strstr(contacts[i].phone, searchTerm) != NULL) {
                    printf(" %d	%s		%s	%s		%s
",
                           i + 1, contacts[i].name, contacts[i].phone, contacts[i].email, contacts[i].address);
                    foundCount++;
                }
            }
            break;

        default:
            printf("잘못된 선택입니다.
");
            return;
    }

    printf("========================================================================================================
");

    if (foundCount == 0) {
        printf("검색 결과가 없습니다.
");
    } else {
        printf("총 %d개의 연락처를 찾았습니다.
", foundCount);
    }
}

// 연락처 수정 함수
void updateContact() {
    if (contactCount == 0) {
        printf("저장된 연락처가 없습니다.
");
        return;
    }

    char searchName[MAX_NAME_LENGTH];
    int index;

    printf("
=== 연락처 수정 ===
");
    printf("수정할 연락처의 이름을 입력하세요: ");
    fgets(searchName, MAX_NAME_LENGTH, stdin);
    searchName[strcspn(searchName, "
")] = '';

    // 연락처 인덱스 찾기
    index = findContactIndex(searchName);

    if (index == -1) {
        printf("이름이 '%s'인 연락처를 찾을 수 없습니다.
", searchName);
        return;
    }

    // 현재 정보 표시
    printf("
현재 연락처 정보:
");
    printContact(index);

    // 새 정보 입력
    printf("
새 정보를 입력하세요 (변경하지 않으려면 Enter 키만 누르세요):
");

    // 이름 수정
    printf("새 이름 (현재: %s): ", contacts[index].name);
    char newName[MAX_NAME_LENGTH];
    fgets(newName, MAX_NAME_LENGTH, stdin);
    newName[strcspn(newName, "
")] = '';

    if (strlen(newName) > 0) {
        strcpy(contacts[index].name, newName);
    }

    // 전화번호 수정
    printf("새 전화번호 (현재: %s): ", contacts[index].phone);
    char newPhone[MAX_PHONE_LENGTH];
    fgets(newPhone, MAX_PHONE_LENGTH, stdin);
    newPhone[strcspn(newPhone, "
")] = '';

    if (strlen(newPhone) > 0) {
        strcpy(contacts[index].phone, newPhone);
    }

    // 이메일 수정
    printf("새 이메일 (현재: %s): ", contacts[index].email);
    char newEmail[MAX_EMAIL_LENGTH];
    fgets(newEmail, MAX_EMAIL_LENGTH, stdin);
    newEmail[strcspn(newEmail, "
")] = '';

    if (strlen(newEmail) > 0) {
        strcpy(contacts[index].email, newEmail);
    }

    // 주소 수정
    printf("새 주소 (현재: %s): ", contacts[index].address);
    char newAddress[MAX_ADDRESS_LENGTH];
    fgets(newAddress, MAX_ADDRESS_LENGTH, stdin);
    newAddress[strcspn(newAddress, "
")] = '';

    if (strlen(newAddress) > 0) {
        strcpy(contacts[index].address, newAddress);
    }

    printf("연락처 정보가 수정되었습니다.
");
}

// 연락처 삭제 함수
void deleteContact() {
    if (contactCount == 0) {
        printf("저장된 연락처가 없습니다.
");
        return;
    }

    char searchName[MAX_NAME_LENGTH];
    int index;
    char confirm;

    printf("
=== 연락처 삭제 ===
");
    printf("삭제할 연락처의 이름을 입력하세요: ");
    fgets(searchName, MAX_NAME_LENGTH, stdin);
    searchName[strcspn(searchName, "
")] = '';

    // 연락처 인덱스 찾기
    index = findContactIndex(searchName);

    if (index == -1) {
        printf("이름이 '%s'인 연락처를 찾을 수 없습니다.
", searchName);
        return;
    }

    // 삭제할 연락처 정보 표시
    printf("
삭제할 연락처 정보:
");
    printContact(index);

    printf("
정말 삭제하시겠습니까? (y/n): ");
    scanf("%c", &confirm);
    clearInputBuffer();

    if (tolower(confirm) == 'y') {
        // 배열에서 해당 연락처 삭제 (뒤의 요소들을 앞으로 이동)
        for (int i = index; i < contactCount - 1; i++) {
            contacts[i] = contacts[i + 1];
        }

        contactCount--;
        printf("연락처가 삭제되었습니다.
");
    } else {
        printf("삭제가 취소되었습니다.
");
    }
}

// 연락처 정렬 함수
void sortContacts() {
    if (contactCount == 0) {
        printf("저장된 연락처가 없습니다.
");
        return;
    }

    // 버블 정렬 알고리즘 사용 (이름순 정렬)
    for (int i = 0; i < contactCount - 1; i++) {
        for (int j = 0; j < contactCount - i - 1; j++) {
            if (strcmp(contacts[j].name, contacts[j + 1].name) > 0) {
                // 연락처 정보 교환
                Contact temp = contacts[j];
                contacts[j] = contacts[j + 1];
                contacts[j + 1] = temp;
            }
        }
    }

    printf("연락처를 이름순으로 정렬했습니다.
");
    displayAllContacts();
}

// 파일에 데이터 저장 함수
void saveToFile() {
    FILE *file = fopen(FILENAME, "wb"); // 바이너리 쓰기 모드로 파일 열기

    if (file == NULL) {
        printf("파일을 열 수 없습니다.
");
        return;
    }

    // 연락처 수 저장
    fwrite(&contactCount, sizeof(int), 1, file);

    // 연락처 데이터 저장
    fwrite(contacts, sizeof(Contact), contactCount, file);

    fclose(file);

    printf("%d개의 연락처가 파일에 저장되었습니다.
", contactCount);
}

// 파일에서 데이터 불러오기 함수
void loadFromFile() {
    FILE *file = fopen(FILENAME, "rb"); // 바이너리 읽기 모드로 파일 열기

    if (file == NULL) {
        printf("데이터 파일이 없거나 열 수 없습니다.
");
        return;
    }

    // 연락처 수 불러오기
    int loadedCount;
    fread(&loadedCount, sizeof(int), 1, file);
    
    // 필요한 경우 배열 용량 확장
    if (loadedCount > capacity) {
        capacity = loadedCount;
        contacts = (Contact*)realloc(contacts, capacity * sizeof(Contact));
        
        if (contacts == NULL) {
            printf("메모리 할당에 실패했습니다.
");
            fclose(file);
            return;
        }
    }
    
    // 연락처 데이터 불러오기
    fread(contacts, sizeof(Contact), loadedCount, file);
    contactCount = loadedCount;
    
    fclose(file);
    
    printf("%d개의 연락처를 파일에서 불러왔습니다.
", contactCount);
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '\n' && c != EOF);
}

// 배열 크기 조정 함수
void resizeArray() {
    capacity *= 2; // 용량을 2배로 증가
    contacts = (Contact*)realloc(contacts, capacity * sizeof(Contact));
    
    if (contacts == NULL) {
        printf("메모리 할당에 실패했습니다.
");
        exit(1);
    }
}

// 이름으로 연락처 인덱스 찾기 함수
int findContactIndex(const char* name) {
    for (int i = 0; i < contactCount; i++) {
        if (strcmp(contacts[i].name, name) == 0) {
            return i;
        }
    }
    return -1; // 찾지 못한 경우
}

// 전화번호로 연락처 인덱스 찾기 함수
int findContactByPhone(const char* phone) {
    for (int i = 0; i < contactCount; i++) {
        if (strcmp(contacts[i].phone, phone) == 0) {
            return i;
        }
    }
    return -1; // 찾지 못한 경우
}

// 연락처 정보 출력 함수
void printContact(int index) {
    printf("이름: %s
", contacts[index].name);
    printf("전화번호: %s
", contacts[index].phone);
    printf("이메일: %s
", contacts[index].email);
    printf("주소: %s
", contacts[index].address);
}

// 입력 버퍼 비우기 함수
void clearInputBuffer() {
    int c;
    while ((c = getchar()) != '
' && c != EOF);
}

// 배열 크기 조정 함수
void resizeArray() {
    // 용량 2배로 증가
    int newCapacity = capacity * 2;

    // 새로운 메모리 할당
    Contact* newContacts = (Contact*)malloc(sizeof(Contact) * newCapacity);

    // 기존 데이터 복사
    for (int i = 0; i < contactCount; i++) {
        newContacts[i] = contacts[i];
    }

    // 기존 메모리 해제
    free(contacts);

    // 새 배열로 교체
    contacts = newContacts;
    capacity = newCapacity;
}

// 이름으로 연락처 인덱스 찾기 함수
int findContactIndex(const char* name) {
    for (int i = 0; i < contactCount; i++) {
        if (strcmp(contacts[i].name, name) == 0) {
            return i;
        }
    }

    return -1; // 찾지 못한 경우
}

// 전화번호로 연락처 인덱스 찾기 함수
int findContactByPhone(const char* phone) {
    for (int i = 0; i < contactCount; i++) {
        if (strcmp(contacts[i].phone, phone) == 0) {
            return i;
        }
    }

    return -1; // 찾지 못한 경우
}

// 특정 인덱스의 연락처 정보 출력 함수
void printContact(int index) {
    printf("이름: %s
", contacts[index].name);
    printf("전화번호: %s
", contacts[index].phone);
    printf("이메일: %s
", contacts[index].email);
    printf("주소: %s
", contacts[index].address);
}
